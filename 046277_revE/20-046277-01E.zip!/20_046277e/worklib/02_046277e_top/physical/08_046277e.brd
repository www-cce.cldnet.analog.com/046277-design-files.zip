# Allegro board 08_046277e.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on L2_GROUND: 12.9,24.98 13.49,25.16 14.2,25.16 14.2,26.76 13.46,26.76 12.98,26.93 9.96,26.93 9.12,26.81 8.38,26.38 4.83,22.82 0.51,22.82 0.51,30.06 0.63,29.93 10.41,29.93 10.41,31.58 18.8,31.58 22.48,35.27 25.27,35.27 24.77,34.76 24.77,32.73 25.65,32.73 25.78,32.85 25.78,34 26.42,34.63 26.67,34.63 27.3,34 27.3,32.73 28.32,32.73 28.32,34.63 27.18,35.77 27.05,35.77 27.05,45.43 20.83,45.43 19.43,46.7 14.99,46.7 14.99,55.33 9.78,55.33 9.78,48.73 0.51,48.73 0.51,65.49 27.43,65.49 27.56,65.62 27.56,68.29 27.69,68.41 75.95,68.41 75.95,0.47 22.86,0.47 22.86,3.14 11.94,3.14 11.94,5.29 0.51,5.29 0.51,20.84 4.93,20.84 5.52,20.95 6.05,21.25 9.65,24.85 9.78,24.95 9.93,24.98 ; 4 cut-outs
GND on L3_SIGNAL: 23.5,0.34 23.5,0.47 22.99,0.47 22.99,3.14 11.94,3.14 11.94,5.42 0.51,5.42 0.51,29.3 11.05,29.3 11.05,34.25 24,34.25 26.7,37.15 29.21,37.15 29.21,31.33 31.37,30.44 31.37,26.63 33.91,26.63 33.91,32.85 32.13,33.62 32.13,41.49 32.77,41.49 32.77,43.01 33.27,43.01 33.27,51.01 29.97,51.01 27.56,57.49 27.56,63.59 25.02,63.59 25.02,63.33 24.36,62.67 24.36,52.53 25.32,48.12 28.88,48.12 28.91,44.41 11.18,44.41 11.18,49.36 0.51,49.36 0.51,64.98 27.56,64.98 27.56,68.54 27.69,68.67 75.95,68.67 75.95,49.87 75.82,49.87 75.82,0.34 ; 6 cut-outs
GND on L4_GROUND, L7_GROUND: 27.56,68.41 75.95,68.41 75.95,0.47 22.86,0.47 22.86,3.14 11.94,3.14 11.94,5.29 0.51,5.29 0.51,65.49 27.43,65.49 27.56,65.62
GND on L6_POWER: 0.38,58.89 13.84,58.89 13.84,61.17 34.29,61.17 34.29,55.21 25.15,55.21 24.38,54.44 24.38,50.25 24.36,34 24.38,33.72 25.43,33.72 27.43,33.74 39.88,33.74 39.88,25.23 24.13,25.23 24.13,5.93 24,5.8 18.29,5.8 18.29,8.47 13.21,8.47 13.21,11.39 13.08,11.52 10.03,11.52 10.03,17.36 0.38,17.36
GND on L9_GROUND: 27.56,68.41 75.95,68.41 75.95,0.47 23.37,0.47 23.37,3.14 11.94,3.14 11.94,5.29 0.51,5.29 0.51,65.49 27.56,65.49
GND on L10_SIGNAL: 27.56,68.41 75.95,68.41 75.95,0.47 23.37,0.47 23.37,3.14 11.94,3.14 11.94,5.29 0.51,5.29 0.51,65.49 27.56,65.49 ; 19 cut-outs
GND on L11_GROUND: 27.56,68.41 75.95,68.41 75.95,0.47 23.37,0.47 23.37,3.14 11.94,3.14 11.94,5.29 0.51,5.29 0.51,65.49 27.56,65.49 ; 1 cut-out
SVDD12 on TOP (solid shape): 32.7,56.33 33.3,56.33 33.84,55.78 33.84,55.69 33.93,55.69 34.61,55.01 34.61,54.99 34.65,54.73 34.8,54.52 34.8,51.01 32.95,51.01 32.51,51.27 32.07,51.01 31.68,51.01 31.24,51.27 30.8,51.01 30.48,51.01 30.1,51.4 30.1,55.33 30.61,55.84 32.39,55.84 32.47,55.93 32.55,55.93 32.55,56.26 32.62,56.33
SVDD12 on L8_POWER: 29.46,55.46 31.24,57.24 37.72,57.24 39.5,55.46 39.5,37.91 36.47,37.91 36.4,37.83 36.45,37.78 36.45,34.89 29.46,34.89
VCC on L5_POWER: 0.63,50.25 0.63,65.37 25.53,65.37 25.53,62.95 19.3,62.95 19.3,50.25
VDDA12 on TOP: 20.07,53.17 20.07,55.46 20.45,55.84 22.35,55.84 22.48,55.97 22.48,56.22 22.61,56.35 23.37,56.35 23.62,56.09 23.62,54.82 23.37,54.57 23.37,53.3 23.11,53.05 20.19,53.05
VDDA12 on L8_POWER: 24.38,57.36 26.42,55.33 26.42,42.51 25.65,41.74 20.32,41.74 19.56,42.51 19.56,55.71 21.21,57.36
VDDA25 on TOP (solid shape): 24.08,42.3 25.17,41.36 25.25,41.29 25.29,41.24 25.35,41.21 25.4,41.16 25.5,41.08 25.65,40.93 25.69,40.91 25.75,40.81 25.85,40.75 25.87,40.74 26.18,40.43 26.19,40.41 26.25,40.31 26.35,40.25 26.37,40.24 26.52,40.09 26.52,39.43 26.52,39.41 26.34,39.23 26.33,39.22 26.25,39.17 26.2,39.09 26.19,39.08 25.84,38.73 25.83,38.72 25.75,38.67 25.7,38.59 25.69,38.58 25.5,38.39 25.3,38.21 25.26,38.18 25.22,38.14 24.16,37.17 22.25,35.82 22.25,38.03 24,38.03 24.84,38.52 25.2,38.75 25.37,38.82 25.63,38.97 25.69,39 25.73,39.05 25.79,39.13 25.86,39.2 25.9,39.27 25.91,39.36 25.91,40.17 25.86,40.39 25.68,40.52 25.4,40.65 24.36,41.31 22.23,41.31 22.23,43.39 22.23,43.4 22.63,43.4
VDDA25 on TOP: 9.4,56.73 9.65,56.73 9.65,55.08 14.35,55.08 14.35,51.27 11.05,51.27 11.05,52.92 9.02,52.92 9.02,55.21 9.4,55.59
VDDA25 on TOP: 7.87,43.78 7.87,35.65 22.25,35.65 22.25,38.19 19.43,38.19 19.43,41.24 22,41.24 22,43.78
VDDA25 on L2_GROUND: 10.03,31.96 18.67,31.96 22.48,35.77 26.54,35.77 26.42,44.54 20.45,44.54 18.67,46.32 14.48,46.32 14.48,55.08 10.16,55.08 10.16,48.35 0.51,48.35 0.56,41.26 18.97,41.26 18.95,39.61 16.41,39.61 10.58,39.62 10.49,39.63 0.51,39.63 0.51,30.31 10.03,30.31 ; 1 cut-out
VDDA25 on L3_SIGNAL: 8.64,43.39 28.37,43.39 28.37,37.81 26.67,37.81 24.18,35.27 8.64,35.27
VDDC12 on TOP: 23.88,54.57 27.69,54.57 27.69,48.09 23.88,48.09
VDDC12 on L6_POWER: 24.77,34.43 24.77,52.41 31.88,52.41 31.95,52.49 34.75,52.49 34.8,52.44 34.8,35.27 34.82,34.38 30.94,34.38 ; 2 cut-outs
VIN_12V on BOTTOM (solid shape): 54.48,33.49 53.09,33.49 53.09,32.85 50.67,32.85 50.67,31.96 50.16,31.94 49.96,31.92 49.78,31.94 49.53,31.96 49.53,32.73 49.15,32.73 49.15,33.74 51.56,33.74 52.58,34.76 53.09,35.39 54.48,35.39
VIN_12V on BOTTOM: 53.85,45.3 53.85,44.16 54.61,43.78 54.61,42 54.99,41.62 56.46,41.62 56.44,43.27 55.65,43.27 55.37,43.65 55.37,45.68 54.36,45.68 54.36,45.3
VIN_12V on BOTTOM: 40.89,36.03 42.29,34.63 43.05,34 43.05,31.2 42.67,31.2 42.16,31.71 42.16,33.62 41.15,33.62 41.15,33.87 41.02,34 38.86,34 38.86,36.03
VIN_12V on BOTTOM: 51.31,19.14 51.31,14.57 54.74,14.57 54.74,19.14
VIN_12V on L8_POWER: 50.16,13.93 50.16,19.14 41.28,19.26 37.36,19.26 37.29,19.34 37.29,36.76 37.31,36.74 41,36.74 41.02,52.28 41.02,56.09 38.86,58.25 21.46,58.25 18.92,55.71 18.92,52.79 18.41,52.28 15.11,52.28 13.84,53.55 12.57,53.55 8,58.13 8,65.49 10.16,65.49 10.16,58.63 13.34,55.46 16.89,55.46 21.84,60.41 40,60.41 43.05,57.36 43.05,52.79 53.47,52.79 53.98,52.28 53.98,48.98 54.74,48.09 54.74,45.93 55.88,44.79 55.88,13.93
3P3VAUX on TOP: 72.9,56.73 73.91,56.73 74.42,56.35 74.42,55.59 73.91,55.08 72.9,55.08
3P3VAUX on L5_POWER: 68.83,66.25 68.83,21.55 68.45,21.17 68.45,19.65 68.83,19.26 75.95,19.26 75.95,66.25
AD9508_VDD on TOP: 49.15,13.04 51.05,13.04 51.05,11.77 50.04,11.77 50.04,10.5 48.77,10.5 48.77,12.15 48.26,12.15 48.26,13.04 48.13,13.17 48.13,16.09 50.04,16.09 50.29,15.84 50.29,14.95 49.53,14.18 49.15,14.18 49.02,14.06 49.02,13.17
AD9508_VDD on TOP: 43.81,12.91 43.81,10.5 45.59,10.5 45.59,12.91
AD9508_VDD on L5_POWER: 41.28,1.74 52.45,1.74 52.45,12.66 43.18,12.66 43.18,10.76 41.28,10.76
ADCLK914VCC on TOP: 11.18,20.53 12.45,20.53 12.45,19.39 13.59,19.39 13.59,19.01 11.56,19.01 11.56,20.03 11.18,20.03
ADCLK914VCC on L8_POWER: 10.29,6.82 10.29,22.44 18.03,22.44 18.03,17.74 16.26,17.74 16.26,6.82
ADF4355_VDD_3V3 on TOP: 10.79,14.06 12.83,14.06 12.83,12.53 10.79,12.53
ADF4355_VDD_3V3 on L10_SIGNAL: 32.13,6.44 33.27,7.58 33.27,13.17 38.23,13.17 38.99,12.41 45.85,12.41 46.99,13.55 46.99,18.38 46.61,18.76 31.12,18.76 28.32,15.96 24.77,15.96 24.26,16.34 24.26,18.38 24,18.63 10.67,18.63 8.89,16.85 8.89,11.64 14.1,6.44
ADF4355_VRF_3V3 on TOP: 17.14,15.45 19.69,15.45 19.69,15.71 20.57,15.71 20.57,15.45 21.59,15.45 21.59,14.06 21.34,13.8 21.34,13.42 21.46,13.3 22.23,13.3 22.23,12.91 21.08,12.91 20.83,13.17 20.83,13.8 18.54,13.8 18.54,13.42 17.14,13.42
ADF4355_VRF_3V3 on TOP: 18.92,11.39 18.92,9.49 15.75,9.49 15.75,11.39
ADF4355_VRF_3V3 on BOTTOM: 16.51,11.52 16.51,9.74 15.24,8.47 15.24,6.56 13.97,5.29 11.81,5.29 11.81,7.33 13.46,7.33 13.46,9.49 15.49,11.52
ADF4355_VRF_3V3 on L5_POWER: 20.7,15.58 21.72,14.57 21.72,5.55 18.16,5.55 18.16,8.22 12.95,8.22 12.95,15.96 15.37,18.38 20.7,18.38
ADF4355_VVCO_5V on TOP: 37.85,6.18 39.75,6.18 39.75,4.91 37.59,4.91 37.34,5.04 37.34,5.8
ADF4355_VVCO_5V on TOP: 21.59,7.83 23.5,7.83 23.75,8.09 23.75,8.85 22.48,8.85 22.23,9.1 22.23,9.36 20.95,9.36 20.83,9.23 20.83,8.09 21.59,8.09
ADF4355_VVCO_5V on L8_POWER: 19.43,3.14 39.75,3.14 39.75,7.96 23.62,7.96 23.62,24.73 18.92,24.73 18.92,7.58 19.43,7.07
ADP5054_1V2 on TOP (solid shape): 57.91,38.06 57.15,38.06 56.73,37.64 56.57,37.64 56.21,37.63 56.24,36.51 54.33,36.51 53.62,37.22 53.34,37.55 52.7,38.19 52.7,39.33 57.91,39.33
ADP5054_1V2 on BOTTOM: 55.88,38.06 55.88,35.88 54.69,35.93 53.52,36.97 53.47,38.06
ADP5054_1V2 on L5_POWER: 32.39,45.55 34.8,45.55 40.39,40.35 43.31,40.35 46.74,43.78 53.47,43.78 57.02,40.22 57.02,34.5 56.77,34.25 28.19,34.25 28.19,41.49 ; 2 cut-outs
ADP5054_1V5 on TOP: 30.61,58.13 32.64,58.13 33.02,58.51 34.92,58.51 34.92,59.52 33.4,61.05 30.48,61.05 30.1,60.67 30.1,58.63
ADP5054_1V5 on TOP: 20.57,58.13 22.61,58.13 22.61,57.62 23.37,57.62 23.62,57.87 23.62,58.38 23.75,58.51 24.89,58.51 24.89,61.43 20.45,61.43 20.07,61.05 20.07,58.63
ADP5054_1V5 on BOTTOM: 40.39,42.51 40.39,42.89 37.72,42.89 37.72,43.39 36.83,43.39 36.83,44.16 37.85,44.16 37.85,45.3 40.89,45.3 40.89,43.78 41.15,43.78 42.04,42.89 42.04,42.51
ADP5054_1V5 on L5_POWER: 37.72,44.66 37.72,43.9 39.37,42.25 43.31,42.25 43.81,42.76 43.81,53.05 34.29,62.57 21.59,62.57 20.7,61.68 20.7,58.63 26.67,52.67 29.72,52.67
ADP5054_3V8 on TOP: 14.22,5.04 14.22,3.01 16.89,3.01 16.89,5.04
ADP5054_3V8 on TOP: 34.29,63.84 35.69,63.84 36.2,64.35 36.2,64.86 36.32,64.98 38.1,64.98 38.61,64.48 42.29,64.48 42.42,64.35 42.42,63.46 41.53,62.57 38.61,62.57 37.97,63.21 34.29,63.21
ADP5054_3V8 on TOP: 9.65,60.92 9.65,60.29 9.14,60.29 9.14,59.02 7.62,59.02 7.62,58.63 6.1,58.63 5.21,59.52 5.21,61.17 9.4,61.17
ADP5054_3V8 on BOTTOM: 42.67,64.73 42.67,63.08 41.28,63.08 40.89,62.7 40.89,61.3 39.24,61.3 39.12,61.43 39.12,63.46 38.1,63.46 38.1,64.73
ADP5054_3V8 on BOTTOM: 54.99,20.66 57.66,20.66 57.66,21.04 59.31,21.04 59.31,18.25 57.28,18.25 57.28,16.72 56.64,16.09 55.12,16.09 54.99,16.22
ADP5054_3V8 on L6_POWER: 55.12,68.03 55.12,36.16 57.53,33.74 57.53,17.23 54.48,14.18 42.55,14.18 42.55,11.39 29.84,11.39 29.72,0.85 22.99,0.85 22.99,3.39 12.07,3.39 12.07,6.18 6.86,6.18 6.86,16.34 9.4,16.34 12.57,13.3 17.78,7.96 24.13,7.96 24.64,8.47 24.64,24.6 41.15,24.6 41.15,65.11 33.78,65.11 33.78,63.21 32.39,61.81 13.34,61.81 13.34,59.65 4.32,59.65 4.32,64.6 27.05,64.6 28.19,65.75 28.19,68.03
ADP5054_5V5 on TOP: 38.86,13.3 38.86,11.14 40.89,11.14 40.89,13.3
ADP5054_5V5 on BOTTOM: 31.22,22.06 31.24,24.12 33.68,24.12 33.66,23.33 34.95,23.33 34.95,22.06
ADP5054_5V5 on L5_POWER: 30.73,24.22 51.82,24.22 51.82,14.06 50.8,13.04 42.04,13.04 42.04,11.26 30.73,11.26
ADP5073_2V2 on BOTTOM: 36.07,51.9 39.75,51.9 39.75,50.25 37.47,50.25 37.47,50.13 36.07,50.13
FMCA_VCC_12P0V on TOP (solid shape): 59.26,10.63 59.36,10.55 59.31,10.44 58.98,8.8 60.65,8.8 60.74,8.83 60.82,8.78 61.74,8.88 61.04,9.49 60.94,9.5 60.89,9.58 60.72,10.08 60.33,10.44 60.28,10.55 60.38,10.63 61.59,10.63 61.98,10.25 61.98,5.29 61.85,5.17 58.93,5.17 58.93,6.18 55.12,6.18 55.12,9.99 55.75,10.63
FMCA_VCC_12P0V on BOTTOM: 51.69,5.29 51.69,1.23 57.4,1.23 57.4,5.29
FMCA_VCC_12P0V on L5_POWER: 71.75,0.6 53.59,0.6 53.59,12.15 60.2,18.76 71.75,18.76
HMC365_VDD on TOP: 34.04,6.69 34.04,7.83 34.16,7.83 34.16,9.23 31.62,9.23 31.62,5.8 33.27,5.8 33.27,6.69
HMC365_VDD on BOTTOM: 29.84,7.83 30.35,7.83 30.35,6.31 31.24,6.31 31.24,8.09 32.51,8.09 32.51,6.56 31.88,6.56 31.88,4.91 29.84,4.91
HMC849_VDD on TOP: 18.92,24.22 19.81,24.22 20.19,23.84 20.19,23.33 24,23.33 24,21.55 22.61,21.55 22.61,22.57 18.92,22.57
HMC849_VDD on L5_POWER: 12.7,16.34 12.7,11.64 9.65,11.64 9.65,24.34 20.7,24.34 20.7,21.93 18.29,21.93
OUT_N on TOP (solid shape): 25.58,39.61 25.58,39.23 23.95,38.36 20.09,38.36 20.09,39.66 25.45,39.66
OUT_P on TOP (solid shape): 25.48,40.17 25.58,40.12 25.58,39.86 25.43,39.84 20.09,39.84 20.09,40.96 24.05,40.98
SA_GND on TOP: 0.51,48.35 10.16,48.35 10.16,44.16 8,44.16 7.98,40.96 0.51,40.96
SA_GND on TOP: 0.51,30.31 10.03,30.31 10.03,34.5 8,34.5 8.03,39.58 3.91,39.58 0.51,39.56
SA_GND on BOTTOM: 0.51,48.35 0.51,30.31 11.56,30.31 11.56,44.03 10.16,44.03 10.16,48.35
SA_GND on L3_SIGNAL: 0.25,48.35 0.25,30.31 10.03,30.31 10.03,34.5 8,34.5 8,44.16 10.16,44.16 10.16,48.35
SPI33 on TOP: 29.59,62.83 29.59,61.17 25.65,61.17 25.65,62.83
SPI33 on L3_SIGNAL: 31.88,27.14 31.88,30.95 29.72,31.71 29.72,40.98 29.18,41.51 29.18,45.48 29.21,45.48 29.72,45.98 29.72,48.6 25.91,48.6 25.15,52.27 25.15,62.57 26.92,62.57 26.92,57.36 28.32,53.3 29.59,50.25 32.77,50.25 32.77,43.39 32.39,43.39 32.39,41.87 31.62,41.87 31.62,33.23 33.4,32.47 33.4,27.14
SUPPLY33 on TOP: 29.84,64.35 33.02,64.35 33.27,64.1 33.27,61.94 32.89,61.56 30.86,61.56 29.72,62.7 29.72,64.22
SUPPLY33 on BOTTOM: 48.13,59.52 48.13,57.36 55.24,57.36 55.37,57.62 55.63,58 55.63,59.52
SUPPLY33 on L8_POWER: 12.19,65.62 27.94,65.62 27.94,68.29 75.95,68.29 75.95,5.8 56.52,5.8 56.51,7.45 51.82,7.45 47.5,11.77 47.5,16.47 46.99,16.98 46.99,18.63 49.53,18.63 49.53,13.17 49.53,13.17 56.48,13.17 56.39,33.49 56.26,43.39 56.26,45.17 55.37,46.06 55.37,52.92 53.98,54.32 47.24,54.32 45.97,55.59 45.97,58.38 43.18,61.17 21.97,61.17 16.89,56.09 13.84,56.09 12.19,57.75
SVSYNC33 on BOTTOM: 39.88,54.95 40.64,54.95 40.64,53.3 38.48,53.3 38.48,58.13 38.35,58.25 36.96,58.25 36.83,58.38 36.83,59.65 37.97,59.65 39.88,57.75
SVSYNC33 on L10_SIGNAL: 37.72,54.19 38.35,54.95 40.77,54.95 40.77,37.68 39.37,36.28 31.88,36.28 31.12,37.04 31.12,44.16 33.15,46.19 34.67,46.19 37.72,49.24 ; 1 cut-out
SW1 on BOTTOM: 48.9,34 48.9,32.73 47.62,32.73 47.62,33.62 48.26,34 48.26,35.27 48.01,35.27 48.01,36.28 46.35,36.28 46.35,37.3 46.61,37.3 46.61,37.81 52.07,37.81 52.07,35.01 51.18,34
SW2 on BOTTOM: 44.83,32.73 43.69,32.73 43.31,33.11 43.31,34.12 42.42,34.89 41.91,35.39 41.91,37.17 44.7,37.17 44.7,37.3 46.1,37.3 46.1,36.28 45.85,36.28 45.85,35.65 45.59,35.39 44.45,35.39 44.45,34.12 44.83,33.74
UNNAMED_3_ADM7150_I1277_EN on BOTTOM: 29.46,12.66 32.89,12.66 32.89,11.14 30.86,11.14 30.86,9.99 29.97,9.99 29.97,11.52 29.46,11.52
UNNAMED_3_ADM7150_I1277_REF on BOTTOM: 28.07,12.28 29.08,12.28 29.08,11.14 29.21,11.01 29.72,11.01 29.72,9.99 28.45,9.99 28.19,10.25 28.19,11.14 28.07,11.26
UNNAMED_4_ADP5054_I1011_SW31 on BOTTOM: 47.12,26.63 47.75,26.63 47.75,25.23 48.13,25.23 48.13,23.96 48.9,23.96 48.9,20.03 49.28,19.77 47.12,19.77
UNNAMED_4_ADP5054_I1011_SW41 on BOTTOM: 45.09,26.63 45.85,26.63 45.85,21.3 44.58,21.3 44.58,25.36 45.09,25.36
UNNAMED_4_ADP5073_I1002_SW on BOTTOM: 42.55,46.19 45.72,46.19 45.72,45.68 45.97,45.43 48.26,45.43 48.51,45.68 48.51,46.19 49.4,46.19 49.53,46.06 49.53,45.43 49.66,45.3 50.8,45.3 51.31,45.68 52.2,45.68 52.2,44.03 43.43,44.03 42.55,44.92
UNNAMED_4_ADP7183_I808_VIN on BOTTOM: 20.83,61.81 21.84,61.81 22.1,61.56 22.1,60.16 23.5,60.16 23.5,58.89 23.37,58.76 21.34,58.76 21.21,58.63 21.21,58 19.3,58 19.3,59.02 19.43,59.14 20.7,59.14 20.83,59.27
UNNAMED_4_CAP_I904_N2 on BOTTOM: 37.59,49.62 43.69,49.62 43.69,48.22 39.62,48.22 39.5,48.09 37.59,48.09
UNNAMED_4_CAP_I948_N2 on BOTTOM: 49.78,19.52 49.78,23.2 50.55,23.96 52.2,23.96 52.58,24.34 52.96,24.34 53.34,24.73 53.34,25.61 53.21,25.74 52.7,25.74 52.32,26.12 52.32,26.88 52.45,27.01 53.47,27.01 53.85,26.63 53.85,24.98 54.23,24.6 56.9,24.6 57.15,24.34 57.15,20.92 54.74,20.92 54.74,21.93 54.86,22.06 54.74,22.19 52.45,22.19 51.69,21.42 51.69,19.52
UNNAMED_4_CAP_I949_N2 on BOTTOM: 44.32,23.84 41.4,23.84 41.15,24.09 37.85,24.09 37.81,24.05 36.21,24.05 35.81,23.66 35.81,21.98 35.99,21.8 37.08,21.8 37.21,21.68 42.8,21.68 42.8,21.17 42.93,21.04 44.32,21.04
UNNAMED_4_CAP_I1125_N1 on BOTTOM: 57.66,39.97 57.66,38.7 56.64,38.7 56.52,38.57 54.74,38.57 54.36,38.19 47.88,38.19 47.88,40.22 49.66,40.22 49.66,42.63 51.18,42.63 51.18,40.22 52.45,40.22 52.45,39.97
UNNAMED_4_CAP_I1127_N1 on BOTTOM: 39.37,38.44 44.58,38.44 44.58,41.36 44.2,41.74 41.4,41.74 41.15,42 38.61,42 38.1,41.62 38.1,39.46
UNNAMED_5_ADCLK914_I223_VREF on TOP: 10.79,17.11 13.59,17.11 13.59,18.25 12.57,18.25 12.57,18.5 10.79,18.5
UNNAMED_5_ADM7150_I186_REF on TOP: 38.73,9.99 40.13,9.99 40.13,9.61 41.78,9.61 41.78,10.76 38.73,10.76
UNNAMED_5_ADM7150_I186_VIN on TOP: 34.92,10.37 36.83,10.37 37.21,9.99 38.48,9.99 38.48,12.91 35.81,12.91 35.81,11.64 34.92,11.64
UNNAMED_5_ADM7154_I181_REF on BOTTOM: 1.65,12.66 2.79,12.66 2.79,14.06 3.05,14.31 3.05,15.2 1.65,15.2
UNNAMED_5_ADM7154_I181_VIN on BOTTOM: 3.05,12.66 6.73,12.66 6.73,11.9 9.91,11.9 9.91,14.06 7.75,14.06 7.62,14.18 7.62,14.44 5.97,14.44 5.97,13.68 3.05,13.68
UNNAMED_5_ADM7154_I181_VOUT on BOTTOM: 3.05,9.36 7.11,9.36 7.11,11.26 8.26,11.26 8.26,5.68 4.45,5.68 4.45,7.83 3.05,7.83
UNNAMED_5_ADM7154_I297_EN on TOP: 12.7,8.22 14.1,8.22 14.1,6.82 16,6.82 16,5.42 12.7,5.42
UNNAMED_5_ADM7154_I297_REF on TOP: 10.67,8.22 12.45,8.22 12.45,5.93 10.67,5.93
UNNAMED_5_CAP_I329_N1 on TOP: 16.76,9.1 18.41,9.1 18.67,8.85 18.67,4.41 18.03,4.41 18.03,5.29 16.76,6.56
VADJ on L6_POWER: 55.63,50 69.34,50 69.34,8.22 60.83,8.22 60.83,12.15 64.39,15.71 64.39,42.25 55.63,42.25
VNEG12 on TOP (solid shape): 25.5,42.1 25.7,41.87 25.68,41.87 25.76,41.83 25.81,41.74 25.98,41.44 26.19,41.36 26.23,41.31 26.29,41.26 26.47,41.08 26.8,40.68 27.28,40.3 27.28,39.13 27.18,39.08 26.77,38.72 26.62,38.49 26.54,38.39 26.37,38.22 26.3,38.17 26.25,38.1 26.01,37.93 25.87,37.72 25.8,37.67 25.75,37.6 25.55,37.4 25.49,37.37 24.98,37.37 24.87,37.48 24.93,37.61 25.43,38.06 25.63,38.24 25.68,38.26 25.7,38.32 25.76,38.34 25.81,38.39 26.11,38.67 26.19,38.72 26.19,38.74 26.21,38.75 26.44,38.95 26.52,39 26.57,39.05 26.87,39.33 26.81,39.74 26.86,40.17 26.52,40.42 26.44,40.47 25.65,41.21 25.35,41.46 24.93,41.89 24.93,42.01 24.99,42.1
VNEG12 on BOTTOM: 16.13,53.05 16.13,54.19 20.7,54.19 20.7,52.92 22.99,52.92 22.99,50.38 22.86,50.25 18.16,50.25 18.16,50.13 14.73,50.13 14.73,51.65
VNEG12 on L10_SIGNAL: 1.14,52.79 13.72,52.79 14.25,53.3 15.24,53.3 18.16,50.38 24.64,50.38 25.53,49.49 25.53,45.81 27.94,44.03 27.94,35.9 26.54,34.63 11.43,34.63 11.43,29.68 1.27,29.68 ; 2 cut-outs
VOUT on BOTTOM: 20.32,57.75 21.46,57.75 21.46,56.86 22.1,56.86 22.1,54.7 21.97,54.7 21.97,53.3 20.95,53.3 20.95,54.7 20.83,54.7 20.83,56.6 20.32,56.6
VREG on L5_POWER: 37.34,33.11 37.34,24.47 54.99,24.47 54.99,33.11

Small or netless copper shapes (teardrops, artwork): 1 on TOP

## Text on the board
BOTTOM: 08-046277 REV E
User.Comments: ASSEMBLY | 01-046277 | 1 | E | 2
Ref Des/Silkscreen Top: PWR ERR | PLL STAT | AD9162-FMCC-EBZ | AD9164-FMCC-EBZ | AD9161-FMCC-EBZ | AD9163-FMCC-EBZ | OUT | EXT CLK | REF IN | DAC IRQ | USB STAT | 12V PWR | GND PWR | USB | 046277 REV E
PAGE_OUTLINE: E | CHANGES PER ECR 095319 | 01JUN20 | B.H.
DIMENSION: 15.    INDICATED VIAS TO BE NON-CONDUCTIVE EPOXY FILLED, AND GROUND FLUSH PRIOR | TO OVER PLATING. | DIFFERENTIAL IMPEDENCE 100 OHMS +/- 10% | LINE WIDTH/SPACE FOR DIFFERENTIAL | IMPEDANCE CONTROLLED LINES = 0.005" LAYERS 1 | LAYER 1 & 12 | 3 PLCS | R.039 | 2.413 | .453 | .425 | SEE NOTE 15
User.8: L2 GROUND | 08-      -07
User.9: L3 SIGNAL | 08-      -08
User.10: 16.    BOARDS TO BE PANELIZED AND SHIPPED INTACT. | 17.    THE FOLLOWING TWO TRACES ON THE PRIMARY SIDE (LAYER)MUST | TRACE BETWEEN C14.2 & T1.3  TO FINISH AT .018" +/- .001" | TRACE BETWEEN J23.1 & C14.1 TO FINISH AT .020" +/- .001" | FINISH AT THE SPECIFIED LINE WIDTHS AFTER ALL PROCESSES. | 09-046277 | 1 | 4 | E
User.11: L4 GROUND | 08-      -09
User.12: L5 POWER | 08-      -10
User.14: L6 POWER | 08-      -11
User.15: L7 GROUND | 08-      -12
User.16: L8 POWER | 08-      -13
User.17: L9 GROUND | 08-      -14
User.18: TACHYON 100G 3.99 MIL | TACHYON 100G 6.64 MIL | TACHYON 100G 3.0 MIL | TACHYON 100G 6.61 MIL | TACHYON 100G 4.00 MIL | 370HR 4.41 MIL | 370HR 5.0  MIL | 370HR 4.52 MIL | 370HR 4.50 MIL | ENIG (Electroless Nickel/Immersion Gold) | PER IPC-4552 LATEST REVISION
User.19: L10 SIGNAL | 08-      -15
User.20: L11 GROUND | 08-      -16
User.35: PRIMARY SIDE | SECONDARY SIDE
User.42: FIGURE | SIZE | 5.0 | 10.0 | 12.0 | 16.0 | 28.0 | 40.0 | 45.0 | 63.0 | 105.0 | 50.0 | 75.0x28.0 | 83.0x28.0 | PLATED | NON-PLATED | FINISHED HOLES IN MILS | ALL UNITS ARE IN MILS | QTY | 145 | 342 | 337 | 8 | 5 | 7 | 1 | 2 | TOLERANCE/NOTES
User.43: FIGURE | SIZE | 8.0 | PLATED | FINISHED HOLES IN MILS | ALL UNITS ARE IN MILS | QTY | 127 | TOLERANCE/NOTES
User.44: FIGURE | SIZE | 8.0 | PLATED | FINISHED HOLES IN MILS | ALL UNITS ARE IN MILS | QTY | 65 | TOLERANCE/NOTES
User.45: FIGURE | SIZE | 10.0 | PLATED | BLIND VIAS LAYER 11 TO LAYER 12 | BLIND VIAS LAYER 1 TO LAYER 2 | FINISHED HOLES IN MILS | ALL UNITS ARE IN MILS | VIAS FROM LAYER  2 TO LAYER 11 | QTY | 9 | TOLERANCE/NOTES | 2 | 3 | 4
