# Allegro board 08_046277e.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CNSMAL554W247H118
  rect 5.537x0.406 smd: 1(-2.769,0)
  rect 5.537x3.607 smd: 2(-2.769,2.261) 3(-2.769,-2.261)
  rect 2.642x6.756 smd: 4(-1.321,0)
CNSMAL562W375H166
  rect 1.702x0.635 smd: 1(1.079,0)
  rect 5.08x2.54 smd: 2(-0.178,4.255) 3(-0.178,4.255) 4(-0.178,-4.255) 5(-0.178,-4.255)
CNTE2041517-1
  round 1.016 hole 0.711: 1(0,0) 2(1,0.8) 3(0,1.6) 4(1,2.4) 5(0,3.2)
  oval 1.219x2.413 hole 0.711x1.905: G1(-1.25,-0.3) G2(2.25,1.6)
  oval 1.219x2.616 hole 0.711x2.108: G3(-1.25,4)
DFN8_2X2_PAD1_5X1
  oval 0.305x0.61 smd: 1(-0.75,-1.05) 2(-0.25,-1.05) 3(0.25,-1.05) 4(0.75,-1.05) 5(0.75,1.05) 6(0.25,1.05) 7(-0.25,1.05) 8(-0.75,1.05)
  rect 1.499x0.991 smd: PAD(0,0)
DFN8_3X3_PAD2_38X1_64
  oval 0.305x0.838 smd: 1(-0.75,-1.45) 2(-0.25,-1.45) 3(0.25,-1.45) 4(0.75,-1.45) 5(0.75,1.45) 6(0.25,1.45) 7(-0.25,1.45) 8(-0.75,1.45)
  rect 2.388x1.651 smd: PAD(0,0)
DFN8_3X3_PAD2_44X1_6_A
  oval 0.305x0.838 smd: 1(-0.75,-1.45) 2(-0.25,-1.45) 3(0.25,-1.45) 4(0.75,-1.45) 5(0.75,1.45) 6(0.25,1.45) 7(-0.25,1.45) 8(-0.75,1.45)
  rect 2.438x1.6 smd: PAD(0,0)
DQFN16_3_5X2_5_PAD2_15X1_15
  oval 0.889x0.229 smd: 1(-1.795,-0.25) 8(1.795,-0.25) 9(1.795,0.25) 16(-1.795,0.25)
  oval 0.229x0.889 smd: 2(-1.25,-1.294) 3(-0.75,-1.294) 4(-0.25,-1.294) 5(0.25,-1.294) 6(0.75,-1.294) 7(1.25,-1.294) 10(1.25,1.294) 11(0.75,1.294) 12(0.25,1.294) 13(-0.25,1.294) 14(-0.75,1.294) 15(-1.25,1.294)
  rect 1.905x0.991 smd: PAD(0,0)
FLSML476W358H146
  rect 3.81x2.489 smd: 1(-6.845,2.1) 2(6.845,2.1) 3(-6.845,-2.1) 4(6.845,-2.1)
  rect 7.899x2.311 smd: 5(1,-5.094)
  rect 3.404x2.311 smd: 6(3.25,5.094)
L0302CS
  rect 0.254x0.533 smd: 1(-0.305,0) 2(0.305,0)
L0402
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
L0603
  rect 0.889x0.813 smd: 1(-0.737,0) 2(0.737,0)
L0603H28
  rect 1.041x0.991 smd: 1(-0.75,0) 2(0.75,0)
L1210
  rect 1.27x1.778 smd: 1(-1.397,0) 2(1.397,0)
LED0603
  rect 0.965x0.762 smd: A(0.8,0) C(-0.8,0)
LED0603H12
  rect 0.787x0.787 smd: A(0.744,0) C(-0.744,0)
LED0805
  rect 1.245x1.092 smd: A(1.172,0) C(-1.172,0)
LP4C
  rect 0.33x0.889 smd: 1(-0.975,-1.841) 2(-0.325,-1.841) 3(0.325,-1.841) 4(0.975,-1.841) 9(0.975,1.841) 10(0.325,1.841) 11(-0.325,1.841) 12(-0.975,1.841)
  rect 0.889x0.33 smd: 5(1.841,-0.975) 6(1.841,-0.325) 7(1.841,0.325) 8(1.841,0.975) 13(-1.841,0.975) 14(-1.841,0.325) 15(-1.841,-0.325) 16(-1.841,-0.975)
  rect 2.388x2.388 smd: PAD(0,0)
LSML75W79H39
  rect 1.041x2.21 smd: 1(-0.724,0) 2(0.724,0)
LSML133W118H79
  rect 1.016x1.778 smd: 1(-0.889,0) 2(0.889,0)
LSMSQ130H55
  custom 0.311x0.311 smd: 1(-1.562,0) 2(1.562,0)
LSMSQ154H71
  custom 0.362x0.362 smd: 1(-1.847,0) 2(1.847,0)
LSMSQ157H83
  rect 1.473x3.683 smd: 1(-1.232,0) 2(1.232,0)
POWERPAKSC70-6
  rect 0.305x0.33 smd: 1(-0.65,-0.91) 2(0,-0.91) 3(0.65,-0.91) 4(0.65,0.91) 5(0,0.91) 6(-0.65,0.91)
  rect 0.61x0.94 smd: PAD1(-0.465,0) PAD2(0.465,0)
QFN16_3X3_PAD1_5X1_5
  oval 0.305x0.889 smd: 1(-0.75,-1.5) 2(-0.25,-1.5) 3(0.25,-1.5) 4(0.75,-1.5) 9(0.75,1.5) 10(0.25,1.5) 11(-0.25,1.5) 12(-0.75,1.5)
  oval 0.889x0.305 smd: 5(1.5,-0.75) 6(1.5,-0.25) 7(1.5,0.25) 8(1.5,0.75) 13(-1.5,0.75) 14(-1.5,0.25) 15(-1.5,-0.25) 16(-1.5,-0.75)
  rect 1.499x1.499 smd: PAD(0,0)
QFN16_3X3_PAD1_6X1_6
  oval 0.305x0.889 smd: 1(-0.75,-1.5) 2(-0.25,-1.5) 3(0.25,-1.5) 4(0.75,-1.5) 9(0.75,1.5) 10(0.25,1.5) 11(-0.25,1.5) 12(-0.75,1.5)
  oval 0.889x0.305 smd: 5(1.5,-0.75) 6(1.5,-0.25) 7(1.5,0.25) 8(1.5,0.75) 13(-1.5,0.75) 14(-1.5,0.25) 15(-1.5,-0.25) 16(-1.5,-0.75)
  rect 1.6x1.6 smd: PAD(0,0)
QFN24_4X4_PAD2_3X2_3
  oval 0.305x0.991 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 13(1.25,2) 14(0.75,2) 15(0.25,2) 16(-0.25,2) 17(-0.75,2) 18(-1.25,2)
  oval 0.991x0.305 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.25) 11(2,0.75) 12(2,1.25) 19(-2,1.25) 20(-2,0.75) 21(-2,0.25) 22(-2,-0.25) 23(-2,-0.75) 24(-2,-1.25)
  rect 2.311x2.311 smd: PAD(0,0)
QFN28_6X6_PAD3_7X3_7
  oval 0.305x1.041 smd: 1(-1.95,-2.979) 2(-1.3,-2.979) 3(-0.65,-2.979) 4(0,-2.979) 5(0.65,-2.979) 6(1.3,-2.979) 7(1.95,-2.979) 15(1.95,2.979) 16(1.3,2.979) 17(0.65,2.979) 18(0,2.979) 19(-0.65,2.979) 20(-1.3,2.979) 21(-1.95,2.979)
  oval 1.041x0.305 smd: 8(2.979,-1.95) 9(2.979,-1.3) 10(2.979,-0.65) 11(2.979,0) 12(2.979,0.65) 13(2.979,1.3) 14(2.979,1.95) 22(-2.979,1.95) 23(-2.979,1.3) 24(-2.979,0.65) 25(-2.979,0) 26(-2.979,-0.65) 27(-2.979,-1.3) 28(-2.979,-1.95)
  rect 3.708x3.708 smd: PAD(0,0)
QFN32_5X5_PAD3_6X3_6
  oval 0.305x0.889 smd: 1(-1.75,-2.451) 2(-1.25,-2.451) 3(-0.75,-2.451) 4(-0.25,-2.451) 5(0.25,-2.451) 6(0.75,-2.451) 7(1.25,-2.451) 8(1.75,-2.451) 17(1.75,2.451) 18(1.25,2.451) 19(0.75,2.451) 20(0.25,2.451) 21(-0.25,2.451) 22(-0.75,2.451) 23(-1.25,2.451) 24(-1.75,2.451)
  oval 0.889x0.305 smd: 9(2.451,-1.75) 10(2.451,-1.25) 11(2.451,-0.75) 12(2.451,-0.25) 13(2.451,0.25) 14(2.451,0.75) 15(2.451,1.25) 16(2.451,1.75) 25(-2.451,1.75) 26(-2.451,1.25) 27(-2.451,0.75) 28(-2.451,0.25) 29(-2.451,-0.25) 30(-2.451,-0.75) 31(-2.451,-1.25) 32(-2.451,-1.75)
  rect 3.607x3.607 smd: PAD(0,0)
QFN38_7X5_PAD5_15X3_15
  oval 0.305x0.838 smd: 1(-2.75,-2.45) 2(-2.25,-2.45) 3(-1.75,-2.45) 4(-1.25,-2.45) 5(-0.75,-2.45) 6(-0.25,-2.45) 7(0.25,-2.45) 8(0.75,-2.45) 9(1.25,-2.45) 10(1.75,-2.45) 11(2.25,-2.45) 12(2.75,-2.45) 20(2.75,2.45) 21(2.25,2.45) 22(1.75,2.45) 23(1.25,2.45) 24(0.75,2.45) 25(0.25,2.45) 26(-0.25,2.45) 27(-0.75,2.45) 28(-1.25,2.45) 29(-1.75,2.45) 30(-2.25,2.45) 31(-2.75,2.45)
  oval 0.838x0.305 smd: 13(3.45,-1.5) 14(3.45,-1) 15(3.45,-0.5) 16(3.45,0) 17(3.45,0.5) 18(3.45,1) 19(3.45,1.5) 32(-3.45,1.5) 33(-3.45,1) 34(-3.45,0.5) 35(-3.45,0) 36(-3.45,-0.5) 37(-3.45,-1) 38(-3.45,-1.5)
  rect 5.156x3.15 smd: PAD(0,0)
QFN48_7X7_PAD5_6X5_6
  oval 0.305x0.94 smd: 1(-2.75,-3.5) 2(-2.25,-3.5) 3(-1.75,-3.5) 4(-1.25,-3.5) 5(-0.75,-3.5) 6(-0.25,-3.5) 7(0.25,-3.5) 8(0.75,-3.5) 9(1.25,-3.5) 10(1.75,-3.5) 11(2.25,-3.5) 12(2.75,-3.5) 25(2.75,3.5) 26(2.25,3.5) 27(1.75,3.5) 28(1.25,3.5) 29(0.75,3.5) 30(0.25,3.5) 31(-0.25,3.5) 32(-0.75,3.5) 33(-1.25,3.5) 34(-1.75,3.5) 35(-2.25,3.5) 36(-2.75,3.5)
  oval 0.94x0.305 smd: 13(3.5,-2.75) 14(3.5,-2.25) 15(3.5,-1.75) 16(3.5,-1.25) 17(3.5,-0.75) 18(3.5,-0.25) 19(3.5,0.25) 20(3.5,0.75) 21(3.5,1.25) 22(3.5,1.75) 23(3.5,2.25) 24(3.5,2.75) 37(-3.5,2.75) 38(-3.5,2.25) 39(-3.5,1.75) 40(-3.5,1.25) 41(-3.5,0.75) 42(-3.5,0.25) 43(-3.5,-0.25) 44(-3.5,-0.75) 45(-3.5,-1.25) 46(-3.5,-1.75) 47(-3.5,-2.25) 48(-3.5,-2.75)
  rect 5.588x5.588 smd: PAD(0,0)
R0201
  rect 0.305x0.406 smd: 1(-0.318,0) 2(0.318,0)
R0402
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
R0603
  rect 1.092x1.194 smd: 1(-0.851,0) 2(0.851,0)
R1206
  rect 1.6x1.6 smd: 1(-1.397,0) 2(1.397,0)
SMB-4
  rect 2.489x2.311 smd: A(2.15,0) C(-2.15,0)
SO8NB-3-PAD
  rect 0.635x1.422 smd: 1(-1.905,-2.819) 2(-0.635,-2.819) 3(0.635,-2.819) 4(1.905,-2.819) 5(1.905,2.819) 6(0.635,2.819) 7(-0.635,2.819) 8(-1.905,2.819)
  rect 2.794x2.413 smd: PAD(0,0)
SOD123-3
  rect 1.194x0.711 smd: A(1.847,0) C(-1.847,0)
TPC65D45
  round 1.651 hole 1.143: 1(0,0)
TPSMC30
  round 0.762 smd: 1(0,0)
TSML150W160H160
  rect 0.762x1.651 smd: 1(-1.27,1.587) 2(0,1.587) 3(1.27,1.587) 4(1.27,-1.587) 5(0,-1.587) 6(-1.27,-1.587)
TSOT-5
  rect 0.508x1.524 smd: 1(-0.95,-1.17) 2(0,-1.17) 3(0.95,-1.17) 4(0.95,1.17) 5(-0.95,1.17)
TSSOP8
  rect 0.33x1.651 smd: 1(-0.975,-2.92) 2(-0.325,-2.92) 3(0.325,-2.92) 4(0.975,-2.92) 5(0.975,2.92) 6(0.325,2.92) 7(-0.325,2.92) 8(-0.975,2.92)
unnamed#2
  round 1.016 smd: (0,0)
unnamed#3
  round 3.175 hole 2.667: 1(0,0)
YSML276W197H71
  rect 1.803x2.007 smd: 1(-2.54,-2) 2(0,-2) 3(2.54,-2) 4(2.54,2) 5(0,2) 6(-2.54,2)

## Nets
GND: C2.2(N2) C3.2(N2) C6.2(N2) C7.2(N2) C9.2(N2) C12.2(N2) C15.2(N2) C16.1 C17.1 C19.2(N2) C20.2(N2) C21.2(N2) C22.2(N2) C23.2(N2) C24.2(N2) C25.2(N2) C26.2(N2) C27.2(N2) C28.2(N2) C29.2(N2) C30.2(N2) C31.2(N2) C37.2(N2) C40.2(N2) C41.1 C42.1 C43.2(N2) C44.1 C45.1 C46.1 C47.1 C48.1 C49.1 C50.2(N2) C51.2(N2) C52.2(N2) C53.2(N2) C54.2(N2) C55.2(N2) C56.2(N2) C57.2(N2) C58.2(N2) C59.2(N2) C60.2(N2) C61.1 C63.1 C64.2(N2) C65.1 C66.1 C67.2(N2) C69.1 C71.2(N2) C72.2(N2) C76.2(N2) C77.2(N2) C310.1 C311.1 C312.1 C313.1 C314.2(N2) C315.1 C316.2(N2) C317.1 C323.1 C325.1 C326.2(N2) C327.2(N2) C328.2(N2) C330.2(N2) C331.2(N2) C338.1 C339.2(N2) C410.1 C411.1 C419.1 C420.1 C424.1 C426.2(N2) C427.1 C429.1 C430.1 C432.1 C433.2(N2) C435.2(N2) C436.2(N2) C437.2(N2) C443.1 C444.1 C446.1 C510.1 C513.1 C514.2(N2) C515.2(N2) C516.2(N2) C518.1 C522.1 C525.2(N2) C532.1 C535.1 C538.2(N2) C539.2(N2) C541.1 C544.2(N2) C545.2(N2) C546.1 C548.N(N2) C550.2(N2) C554.2(N2) C558.2(N2) C564.N(N2) C566.P C567.2(N2) C612.2(N2) C614.2(N2) C616.2(N2) C617.2(N2) C618.2(N2) C619.2(N2) C620.2(N2) C622.2(N2) C623.2(N2) C626.2(N2) C628.2(N2) C631.2(N2) C636.2(N2) C637.2(N2) C643.2(N2) C645.1 C648.2(N2) C649.1 C651.1 C654.2(N2) C655.2(N2) C656.1 C657.1 C658.1 C659.1 C660.1 C661.1 C662.1 C663.1 C664.1 C665.1 C666.1 C667.1 C668.1 C669.1 C670.1 C818.1 D1.A(P) FL1.3(PSG) FL1.4 FL1.5 FL1.6 J31.2 J31.3 J31.4 J31.5(SH4) J61.2 J61.3(SH2) J62.2 J62.3(SH2) L3.2(N2) L4.2(N2) L45.1 P1.A1 P1.A4 P1.A5 P1.A8 P1.A9 P1.A12 P1.A13 P1.A16 P1.A17 P1.A20 P1.A21 P1.A24 P1.A25 P1.A28 P1.A29 P1.A32 P1.A33 P1.A36 P1.A37 P1.A40 P1.B2 P1.B3 P1.B6 P1.B7 P1.B10 P1.B11 P1.B14 P1.B15 P1.B18 P1.B19 P1.B22 P1.B23 P1.B26 P1.B27 P1.B30 P1.B31 P1.B34 P1.B35 P1.B38 P1.B39 P1.C1 P1.C4 P1.C5 P1.C8 P1.C9 P1.C12 P1.C13 P1.C16 P1.C17 P1.C20 P1.C21 P1.C24 P1.C25 P1.C28 P1.C29 P1.C32 P1.C33 P1.C36 P1.C38 P1.C40 P1.D2 P1.D3 P1.D6 P1.D7 P1.D10 P1.D16 P1.D19 P1.D22 P1.D25 P1.D28 P1.D37 P1.D39 P1.E1 P1.E4 P1.E5 P1.E8 P1.E11 P1.E14 P1.E17 P1.E20 P1.E23 P1.E26 P1.E29 P1.E32 P1.E35 P1.E38 P1.E40 P1.F2 P1.F3 P1.F6 P1.F9 P1.F12 P1.F15 P1.F18 P1.F21 P1.F24 P1.F27 P1.F30 P1.F33 P1.F36 P1.F39 P1.G1 P1.G4 P1.G5 P1.G8 P1.G11 P1.G14 P1.G17 P1.G20 P1.G23 P1.G26 P1.G29 P1.G32 P1.G35 P1.G38 P1.G40 P1.H2 P1.H3 P1.H6 P1.H9 P1.H12 P1.H15 P1.H18 P1.H21 P1.H24 P1.H27 P1.H30 P1.H33 P1.H36 P1.H39 P1.J1 P1.J4 P1.J5 P1.J8 P1.J11 P1.J14 P1.J17 P1.J20 P1.J23 P1.J26 P1.J29 P1.J32 P1.J35 P1.J38 P1.J40 P1.K2 P1.K3 P1.K6 P1.K9 P1.K12 P1.K15 P1.K18 P1.K21 P1.K24 P1.K27 P1.K30 P1.K33 P1.K36 P1.K39 Q1.1 Q1.4(S2) Q2.1 Q2.4(S2) Q3.1 Q3.4(S2) Q4.1 Q4.4(S2) R1.2(N2) R3.2(N2) R8.1 R9.2(N2) R15.1 R17.2(N2) R27.2(N2) R41.1 R42.2(N2) R60.2(N2) R61.1 R67.2(N2) R69.1 R76.2(N2) R78.2(N2) R80.2(N2) R88.1 R310.1 R311.1 R328.1 R330.2(N2) R413.2(N2) R417.1 R423.2(N2) R424.2(N2) R429.1 R436.2(N2) R617.2(N2) R618.2(N2) R621.1 R623.2(N2) T33.2 TP42.1(N1) TP64.1(N1) U1.A1 U1.A11 U1.B2 U1.B3 U1.C2 U1.C3 U1.C4 U1.C10 U1.C11 U1.C12 U1.C13 U1.D1 U1.D6 U1.D7 U1.E2 U1.E3 U1.E4 U1.E7 U1.E10 U1.E11 U1.E12 U1.E13 U1.F3 U1.F4 U1.F5 U1.F6 U1.F7 U1.F8 U1.F9 U1.F10 U1.F11 U1.F13 U1.G1 U1.G2 U1.G12 U1.G13 U1.H7 U1.J1 U1.J2 U1.J6 U1.J7 U1.J8 U1.J12 U1.J13 U1.K6 U1.L1 U1.L2 U1.L6 U1.L8 U1.L12 U1.L13 U1.M1 U1.M2 U1.M4 U1.M6 U1.M8 U1.M10 U1.M12 U1.M13 U1.N2 U1.N4 U1.N6 U1.N7 U1.N8 U1.N10 U1.N12 U2.7 U2.PAD U3.7 U3.PAD U4.2 U5.5 U5.10 U5.11 U5.PAD U6.4 U6.PAD U7.PAD U8.9 U8.12 U8.13 U8.14 U8.24 U8.30 U8.PAD U9.8 U9.PAD U10.2 U10.3 U10.10 U10.11 U10.30 U10.PAD U11.10 U11.PAD U12.6 U13.4 U13.PAD U14.4 U14.PAD U15.8 U15.9 U15.13 U15.18 U15.21 U15.31 U15.PAD U16.7 U16.14 U16.PAD U17.4 U17.PAD U18.4 U18.PAD U19.4 U19.PAD U20.5 U20.16 U20.PAD U21.8 U21.10 U21.PAD U22.8 U22.PAD U23.4 U23.7(WC_N) XC4.N(N2) XC5.2(N2) XC6.2(N2) XC12.1 XP1.6(N6) XP2.5 XP2.G1 XP2.G2 XP2.G3(N8) Y61.3
SVDD12: C20.1 C26.1 C31.1 C37.1 C43.1 C52.1 C532.2(N2) C535.2(N2) C541.2(N2) C546.2(N2) C554.1 C567.1 U1.H3 U1.H6 U1.H8 U1.H11 U1.J3 U1.J11 U1.K3 U1.K7 U1.K8 U1.K11(VTT_1P2_2) U1.L3 U1.L4 U1.L5 U1.L9 U1.L10 U1.L11 U1.N1 U1.N13 U3.9 U3.10 U3.11 U3.12 U3.13
VCC: C58.1 R29.1 R30.1 R40.1 R50.2(N2) R51.2(N2) R52.2(N2) R53.1 R55.2(N2) R56.2(N2) R57.2(N2) R58.2(N2) R63.1 R68.1 R77.1 R79.1 R327.1 U8.22 U8.25(VSEL)
VDDA12: C50.1 C558.1 E9.1 U1.B10 U1.B11 U2.9 U2.10 U2.11 U2.12 U2.13
VDDA25: C1.2(N2) C5.2(N2) C32.2 C32.4 C32.6 C32.8(N8) C33.2 C33.4 C33.6 C33.8(N8) C35.2(N2) C36.2(N2) C513.2(N2) C531.1 C534.1 C537.1 C543.1 C549.1 R33.1 R34.2(N2) R59.1 T1.1 T1.2 T1.6 U1.A3 U1.A5 U1.A8 U1.A10 U1.B4 U1.B6 U1.B7 U1.B9 U1.B12 U1.C5 U1.C8 U13.2
VDDA25_EN: Q4.3 Q4.PAD2 R52.1 U13.7
VDDC12: C526.P C533.1 C536.1 C539.1 C545.1 E9.2(N2) U1.D2 U1.D3 U1.D4 U1.D5 U1.D8 U1.D9 U1.D10 U1.D11 U1.D12 U1.D13 U1.E1
VIN_12V: C41.2(N2) C42.2(N2) C44.2(N2) C45.2(N2) C433.1 DS2.A(P) FL1.2 R54.1 R428.1 U10.6 U10.7 U10.22 U10.23 U10.24 U10.36 U10.37 U10.38 U11.12 U11.13
3P3VAUX: C818.2(N2) P1.D32 U23.8
73_SYNC: R429.2(N2) U11.4
73_VREF: C429.2(N2) R434.2(N2) U11.9
73_VREG: C430.2(N2) R425.1 U11.11(VREG)
AD9508_VDD: C323.2(N2) C327.1 C328.1 C330.1 C331.1 E32.1 R35.2(N2) R36.2(N2) R38.2(N2) R39.2(N2) R312.1 R313.1 U7.6 U7.13(VDD_2)
ADCLK914OUT: C39.1 R625.1 U16.11
ADCLK914VCC: C654.1 C655.1 E68.2(N2) R622.1 R625.2(N2) U16.8 U16.13
ADF4355_VDD_3V3: C614.1 C616.1 C669.2(N2) JP1.2(S2) R611.2(N2) R619.2(N2) U15.5 U15.16 U15.27 U18.2
ADF4355_VRF_3V3: C623.1 C626.1 E5.1 E67.2(N2) L61.1 L62.2(N2) U15.10
ADF4355_VVCO_5V: C618.1 C619.1 C636.1 C643.1 C668.2(N2) U15.6 U15.17(VVCO) U15.19 U17.2
ADF4355OUTA: C632.2(N2) U16.2
ADF4355OUTAB: C633.2(N2) U16.1
ADF4355OUTB: C638.2(N2) U9.7
ADF4355OUTBB: C639.2(N2) U9.5
ADP5054_1V2: C2.1 C3.1 C16.2(N2) C17.2(N2) C18.1 C525.1 C538.1 C544.1 C550.1 C564.P E8.2(N2) R16.2(N2) U1.E5 U1.E6 U1.E8 U1.E9 U1.G5 U1.G6 U1.G7 U1.G8 U1.G9
ADP5054_1V5: C19.1 C28.1 C29.1 E1.2(N2) R2.2(N2) R24.1 R25.1 U2.1 U2.2 U2.3 U2.4 U2.16 U3.1 U3.2 U3.3 U3.4
ADP5054_3V8: C6.1 C56.1 C420.2(N2) C516.1 E2.2(N2) L1.1 L5.1 R63.2(N2) U4.1 U13.8 U14.8
ADP5054_5V5: C419.2(N2) E3.2(N2) E31.1 L2.1
ADP5073_2V2: C446.2(N2) E49.1 R443.1
CLK_N: C349.2(N2) U1.C1
CLK_P: C348.2(N2) U1.B1
CPOUT: C61.2(N2) C62.1 R62.1 U15.7
CS1: P2.2 R19.1 U20.20 U21.14
CS2: R38.1 R316.1 U20.10 U22.11
CS3: R615.1 U20.4 U22.13
DAC_CSB: R19.2(N2) U1.F12
DAC_SCLK: R23.2(N2) U1.H10
DAC_SDIO: R22.2(N2) U1.G10
DAC_SDO: R20.2(N2) U1.G11
DAC_TXEN_0: R8.2(N2) R18.2(N2) U1.G3
DIV2IN: C341.2(N2) U7.21
DIV2INB: C340.2(N2) U7.22
DL1: Q1.2 U10.31
DL2: Q1.5 U10.29
EN: Q3.3 Q3.PAD2 R51.1 U4.3
FMC_CS1: P1.H11 U21.3
FMC_CS2: P1.D11 U22.6
FMC_CS3: P1.D14 U22.4
FMC_HMC849VCTL: P1.D15 U22.3
FMC_MISO: P1.H10 U21.5
FMC_MOSI: P1.G10 U21.4
FMC_SCK: P1.G9 U21.6
FMC_SCL: P1.C30 U23.6
FMC_SDA: P1.C31 U23.5
FMC_SPI_EN: P1.D12 R72.2(N2) R73.2(N2) U20.6 U21.9 U22.9
FMC_TXEN_0: P1.H13 U22.5
FMCA_VCC_12P0V: C548.P D1.C FL1.1 P1.C35 P1.C37 TP41.1(N1)
GA0: P1.C34 U23.1
GA1: P1.D35 U23.2
GBTCLK0_M2C_N: C333.2(N2) P1.D5
GBTCLK0_M2C_P: C334.2(N2) P1.D4
HMC365_VDD: C317.2(N2) C338.2(N2) C339.1 U6.2 U9.4(VCC)
HMC365OUT: C341.1 R37.2(N2) R329.2(N2) U9.3
HMC365OUTB: C340.1 R37.1 R328.2(N2) U9.1
HMC849_VDD: C311.2(N2) C314.1 C316.1 E66.2(N2) U5.1(VDD)
HMC849VCTL: R31.2(N2) U20.9 U22.14
IRQB: CR5.C TP21.1(N1) U1.G4
LTC2928_ON: R70.2(N2) R416.1 U10.17
LTC2928_ON_A: R71.2(N2) U11.3
MISO: R20.1 U20.19 U21.12
MOSI: P2.1 R22.1 R36.1 R315.1 R614.1 U20.18 U21.13
OUT_N: R33.2(N2) T1.5(SEC_DOT) U1.A6
OUT_P: R34.1 T1.4 U1.A7
PG_C2M: P1.D1 R47.2(N2) R410.2(N2) R411.2(N2) R412.2(N2) R428.2(N2) R436.1 U11.6
PGC: U20.24 XP1.3
PWRGD: DS1.C U8.19 U20.28
REF: R75.2(N2) U8.5
REF_4355_N: C610.1 Y61.5
REF_4355_P: C611.1 R65.1 Y61.4
SA_GND: C1.1 C5.1 C32.1 C32.3 C32.5 C32.7 C33.1 C33.3 C33.5 C33.7 C35.1 C36.1 J32.2 J32.3 J32.4(SH3) L3.1 L4.1
SCK: P2.3(N3) R23.1 R35.1 R314.1 R613.1 U20.15 U21.11
SERDIN0_N: C816.1 U1.H12
SERDIN0_P: C815.1 U1.H13
SERDIN1_N: C82.1 U1.K12
SERDIN1_P: C81.1 U1.K13
SERDIN2_N: C84.1 U1.N11
SERDIN2_P: C83.1 U1.M11
SERDIN3_N: C86.1 U1.N9
SERDIN3_P: C85.1 U1.M9
SERDIN4_N: C811.1 U1.N5
SERDIN4_P: C812.1 U1.M5
SERDIN5_N: C87.1 U1.N3
SERDIN5_P: C88.1 U1.M3
SERDIN6_N: C813.1 U1.K2
SERDIN6_P: C814.1 U1.K1
SERDIN7_N: C89.1 U1.H2
SERDIN7_P: C810.1 U1.H1
SLEW: R425.2(N2) U11.2
SPI33: C59.1 E4.2(N2) R5.1 R6.1 U1.H5 U1.H9
SUPPLY33: C9.1 C76.1 C77.1 E4.1 E32.2(N2) R28.2(N2) R66.1 U4.5(VOUT) U20.11(VUSB) U20.17 U21.16(VCCB) U22.16(VCCB) XC4.P XC5.1 XC6.1 XP1.2 XR2.1 XR6.1
SVPLL12_EN: R338.2(N2) U3.16
SVSYN33_EN: R339.2(N2) U14.7
SVSYNC33: C522.2(N2) U1.K4 U1.K10 U14.2
SW1: C10.2(N2) L6.1 Q1.6 Q1.PAD1 U10.33 U10.34 U10.35
SW2: C412.2(N2) L7.1 Q1.3 Q1.PAD2 U10.25 U10.26 U10.27
SWITCH2BALUN: C38.1 R332.1
SYNC_N: JP34.1 R26.1 SYNCN.1(N1) U1.J9
SYNC_P: JP33.1 R26.2(N2) SYNCP.1(N1) U1.J10
SYSREF2_N: C344.2(N2) JP32.1
SYSREF2_P: C345.2(N2) JP31.1
SYSREF_N: C346.2(N2) R32.1 SYSRFN.1(N1) U1.F2
SYSREF_P: C347.2(N2) R32.2(N2) SYSRFP.1(N1) U1.F1
TOAD9508: R329.1 R629.2(N2)
TXEN_0: R18.1 U20.8 U22.12
UNNAMED_2_AD916X_I16_ISET: R7.1 U1.A12
UNNAMED_2_AD916X_I16_PLLLDOBYPA: R21.2(N2) U1.M7
UNNAMED_2_AD916X_I16_RESETB: R4.1 U1.H4
UNNAMED_2_AD916X_I16_VBGNEG: C8.1 U1.C9
UNNAMED_2_AD916X_I16_VREF: C23.1 U1.A13
UNNAMED_2_CAP_I5_N1: C21.1 R21.1
UNNAMED_2_CAP_I7_N1: C7.1 R3.1 R4.2(N2) R5.2(N2)
UNNAMED_2_DIOLED_I17_P: CR5.A(P) R6.2(N2)
UNNAMED_3_AD9508_I1155_CSN: R316.2(N2) U7.1
UNNAMED_3_AD9508_I1155_EXTCAP0: C325.2(N2) U7.5
UNNAMED_3_AD9508_I1155_EXTCAP1: C326.1 U7.14
UNNAMED_3_AD9508_I1155_INSEL: R39.1 R330.1 U7.23
UNNAMED_3_AD9508_I1155_OUT0: C333.1 U7.2
UNNAMED_3_AD9508_I1155_OUT0N: C334.1 U7.3
UNNAMED_3_AD9508_I1155_OUT2: C344.1 U7.11
UNNAMED_3_AD9508_I1155_OUT2N: C345.1 U7.12
UNNAMED_3_AD9508_I1155_OUT3: C346.1 U7.16
UNNAMED_3_AD9508_I1155_OUT3N: C347.1 U7.17
UNNAMED_3_AD9508_I1155_RESETN: R311.2(N2) R312.2(N2) U7.18
UNNAMED_3_AD9508_I1155_SCLK: R314.2(N2) U7.19
UNNAMED_3_AD9508_I1155_SDIO: R315.2(N2) U7.24
UNNAMED_3_AD9508_I1155_SYNCN: R310.2(N2) R313.2(N2) U7.20
UNNAMED_3_ADHMC849_I1139_VCTL: R31.1 U5.2
UNNAMED_3_ADM7150_I1277_BYP: C312.2(N2) U6.3
UNNAMED_3_ADM7150_I1277_EN: C313.2(N2) E31.2(N2) U6.7 U6.8
UNNAMED_3_ADM7150_I1277_REF: C315.2(N2) U6.5 U6.6
UNNAMED_3_ADM7150_I1277_VREG: C310.2(N2) U6.1(VREG)
UNNAMED_3_CAP_I1148_N2: C39.2(N2) U5.12
UNNAMED_3_CAP_I1149_N2: C34.2(N2) U5.9
UNNAMED_3_CAP_I1150_N2: C38.2(N2) U5.3
UNNAMED_3_CAP_I1305_N1: C349.1 T33.6(SEC_DOT)
UNNAMED_3_CAP_I1306_N1: C348.1 T33.4
UNNAMED_3_CAP_I1318_N1: C14.1 J32.1
UNNAMED_3_CAP_I1318_N2: C14.2(N2) T1.3
UNNAMED_3_CNBNC5P_I1037_CNTR: C34.1 J31.1
UNNAMED_3_RES_I1265_N2: R332.2(N2) T33.3
UNNAMED_4_ADP5054_I1011_BST1: C10.1 U10.32
UNNAMED_4_ADP5054_I1011_BST2: C412.1 U10.28
UNNAMED_4_ADP5054_I1011_BST3: C413.1 U10.1
UNNAMED_4_ADP5054_I1011_BST4: C415.1 U10.12
UNNAMED_4_ADP5054_I1011_CFG12: R41.2(N2) R48.1 U10.18
UNNAMED_4_ADP5054_I1011_CFG34: R42.1 R49.1 U10.13
UNNAMED_4_ADP5054_I1011_COMP1: R44.2(N2) U10.40
UNNAMED_4_ADP5054_I1011_COMP2: R45.2(N2) U10.20
UNNAMED_4_ADP5054_I1011_COMP3: R46.2(N2) U10.47
UNNAMED_4_ADP5054_I1011_COMP4: R43.2(N2) U10.15
UNNAMED_4_ADP5054_I1011_EN1: R47.1 U10.39
UNNAMED_4_ADP5054_I1011_EN2: R410.1 U10.21
UNNAMED_4_ADP5054_I1011_EN3: R411.1 U10.48
UNNAMED_4_ADP5054_I1011_EN4: R412.1 U10.14
UNNAMED_4_ADP5054_I1011_FB1: C11.1 R15.2(N2) R16.1 U10.41
UNNAMED_4_ADP5054_I1011_FB2: C13.1 R1.1 R2.1 U10.19
UNNAMED_4_ADP5054_I1011_FB3: R420.2(N2) R424.1 U10.46
UNNAMED_4_ADP5054_I1011_FB4: R419.2(N2) R423.1 U10.16
UNNAMED_4_ADP5054_I1011_RT: R413.1 U10.42
UNNAMED_4_ADP5054_I1011_SW31: C413.2(N2) L44.1 U10.4 U10.5
UNNAMED_4_ADP5054_I1011_SW41: C415.2(N2) L42.1 U10.8 U10.9
UNNAMED_4_ADP5054_I1011_SYNC: R414.2(N2) U10.44
UNNAMED_4_ADP5054_I1011_VDD: C411.2(N2) U10.43
UNNAMED_4_ADP5073_I1002_COMP: C436.1 R437.1 U11.7
UNNAMED_4_ADP5073_I1002_FB: R430.2(N2) R434.1 U11.8
UNNAMED_4_ADP5073_I1002_SW: D42.C L45.2(N2) U11.1
UNNAMED_4_ADP7183_I808_VA: C434.2(N2) C435.1 U12.3
UNNAMED_4_ADP7183_I808_VAFB: C434.1 U12.4
UNNAMED_4_ADP7183_I808_VIN: C426.1 R443.2(N2) U12.8 U12.PAD
UNNAMED_4_ADP7183_I808_VREG: C427.2(N2) U12.7(VREG)
UNNAMED_4_CAP_I904_N2: C424.2(N2) D42.A(P) E49.2(N2) R430.1
UNNAMED_4_CAP_I948_N2: C443.2(N2) E2.1 L44.2(N2) R420.1
UNNAMED_4_CAP_I949_N2: C444.2(N2) E3.1 L42.2(N2) R419.1
UNNAMED_4_CAP_I1000_N1: C437.1 R437.2(N2)
UNNAMED_4_CAP_I1019_N2: C47.2(N2) R44.1
UNNAMED_4_CAP_I1026_N2: C48.2(N2) R45.1
UNNAMED_4_CAP_I1027_N2: C49.2(N2) R46.1
UNNAMED_4_CAP_I1028_N2: C46.2(N2) R43.1
UNNAMED_4_CAP_I1107_N2: C18.2(N2) R17.1
UNNAMED_4_CAP_I1125_N1: C11.2(N2) C12.1 C53.1 E8.1 L6.2(N2)
UNNAMED_4_CAP_I1127_N1: C13.2(N2) C15.1 C54.1 E1.1 L7.2(N2)
UNNAMED_4_DIOLED_I1138_N: DS2.C R417.2(N2)
UNNAMED_5_ADCLK914_I223_Q: C4.1 R622.2(N2) U16.12
UNNAMED_5_ADCLK914_I223_VREF: C649.2(N2) U16.15 U16.16
UNNAMED_5_ADF4355_I299_CE: R611.1 U15.4
UNNAMED_5_ADF4355_I299_CLK: R613.2(N2) U15.1
UNNAMED_5_ADF4355_I299_CREG2: C612.1 C617.1 U15.32
UNNAMED_5_ADF4355_I299_DATA: R614.2(N2) U15.2
UNNAMED_5_ADF4355_I299_LE: R615.2(N2) U15.3
UNNAMED_5_ADF4355_I299_MUXOUT: R620.1 U15.30
UNNAMED_5_ADF4355_I299_REFINA: C611.2(N2) R69.2(N2) R612.1 U15.29
UNNAMED_5_ADF4355_I299_REFINB: C610.2(N2) R612.2(N2) U15.28
UNNAMED_5_ADF4355_I299_RFOUTB: L64.1 R11.2(N2) R13.1 U15.15
UNNAMED_5_ADF4355_I299_RFOUTB_1: L63.2(N2) R11.1 R12.1 U15.14
UNNAMED_5_ADF4355_I299_RSET: R618.1 U15.22
UNNAMED_5_ADF4355_I299_VBIAS: C637.1 C645.2(N2) U15.24
UNNAMED_5_ADF4355_I299_VREF: C648.1 C651.2(N2) U15.23
UNNAMED_5_ADM7150_I186_BYP: C659.2(N2) U17.3
UNNAMED_5_ADM7150_I186_REF: C665.2(N2) U17.5 U17.6
UNNAMED_5_ADM7150_I186_VIN: C662.2(N2) L2.2(N2) U17.7 U17.8
UNNAMED_5_ADM7150_I186_VREG: C656.2(N2) U17.1(VREG)
UNNAMED_5_ADM7154_I181_BYP: C661.2(N2) U19.3
UNNAMED_5_ADM7154_I181_REF: C667.2(N2) U19.5 U19.6
UNNAMED_5_ADM7154_I181_VIN: C664.2(N2) L1.2(N2) U19.7 U19.8
UNNAMED_5_ADM7154_I181_VOUT: C670.2(N2) R626.1 R627.1 R628.1 U19.2
UNNAMED_5_ADM7154_I181_VREG: C658.2(N2) U19.1(VREG)
UNNAMED_5_ADM7154_I297_BYP: C660.2(N2) U18.3
UNNAMED_5_ADM7154_I297_EN: C663.2(N2) L5.2(N2) U18.7 U18.8
UNNAMED_5_ADM7154_I297_REF: C666.2(N2) U18.5 U18.6
UNNAMED_5_ADM7154_I297_VREG: C657.2(N2) U18.1(VREG)
UNNAMED_5_CAP_I32_N2: C66.2(N2) R62.2(N2) R64.1
UNNAMED_5_CAP_I90_N1: C633.1 L62.1 U15.12
UNNAMED_5_CAP_I203_N2: C63.2(N2) C65.2(N2) JP1.1 Y61.6(VDD)
UNNAMED_5_CAP_I269_N1: C620.1 C622.1 U15.25
UNNAMED_5_CAP_I292_N1: C638.1 R12.2(N2) R14.1
UNNAMED_5_CAP_I293_N1: C639.1 R13.2(N2) R14.2(N2)
UNNAMED_5_CAP_I294_N1: C632.1 L61.2(N2) U15.11
UNNAMED_5_CAP_I329_N1: C628.1 C631.1 E5.2(N2) L63.1 L64.2(N2)
UNNAMED_5_CAP_I349_N2: C62.2(N2) R61.2(N2)
UNNAMED_5_CNBNC3P_I279_CNTR: C4.2(N2) J62.1 R623.1
UNNAMED_5_CNBNC3P_I308_CNTR: J61.1 R65.2(N2) R629.1
UNNAMED_5_DIOLED_I73_N: DS61.C R621.2(N2)
UNNAMED_5_DIOLED_I73_P: DS61.A(P) R620.2(N2)
UNNAMED_5_FERRITE_I346_N1: E68.1 R626.2(N2)
UNNAMED_5_FERRITE_I347_N1: E67.1 R628.2(N2)
UNNAMED_5_FERRITE_I348_N1: E66.1 R627.2(N2)
UNNAMED_5_RES_I49_N1: R617.1 R619.1 U15.26
UNNAMED_6_CAP_I116_N2: U20.3 XC12.2(N2)
UNNAMED_6_CN6P_I38_N1: U20.25 XP1.1
UNNAMED_6_CN6P_I38_N5: U20.26 XP1.5 XR2.2(N2)
UNNAMED_6_DIOLED_I258_N: U20.21 XCR1.C
UNNAMED_6_DIOLED_I258_P: XCR1.A(P) XR6.2(N2)
UNNAMED_6_ICPIC18F2XJ50_I109_OS: R28.1 U20.7
UNNAMED_6_ICPIC18F2XJ50_I109_RC: R10.1 U20.14
UNNAMED_7_CAP_I162_N2: C811.2(N2) P1.B32
UNNAMED_7_CAP_I163_N2: C812.2(N2) P1.B33
UNNAMED_7_CAP_I164_N2: C813.2(N2) P1.B36
UNNAMED_7_CAP_I165_N2: C814.2(N2) P1.B37
UNNAMED_7_CAP_I166_N2: C82.2(N2) P1.A23
UNNAMED_7_CAP_I167_N2: C81.2(N2) P1.A22
UNNAMED_7_CAP_I168_N2: C84.2(N2) P1.A27
UNNAMED_7_CAP_I169_N2: C83.2(N2) P1.A26
UNNAMED_7_CAP_I170_N2: C86.2(N2) P1.A31
UNNAMED_7_CAP_I171_N2: C85.2(N2) P1.A30
UNNAMED_7_CAP_I172_N2: C88.2(N2) P1.A35
UNNAMED_7_CAP_I173_N2: C87.2(N2) P1.A34
UNNAMED_7_CAP_I174_N2: C810.2(N2) P1.A39
UNNAMED_7_CAP_I175_N2: C89.2(N2) P1.A38
UNNAMED_7_CAP_I176_N2: C816.2(N2) P1.C3
UNNAMED_7_CAP_I177_N2: C815.2(N2) P1.C2
UNNAMED_7_CN400PAKV2_I143_LA01N: JP34.2(N2) P1.D9
UNNAMED_7_CN400PAKV2_I143_LA01P: JP33.2(N2) P1.D8
UNNAMED_7_CN400PAKV2_I143_TDI: P1.D30 P1.D31
UNNAMED_7_CN400PAKV2_I147_LA02N: JP32.2(N2) P1.H8
UNNAMED_7_CN400PAKV2_I147_LA02P: JP31.2(N2) P1.H7
UNNAMED_7_ICM24CXX_I210_E2: R88.2(N2) U23.3
UNNAMED_9_ADM7154_I249_BYP: C515.1 U14.3
UNNAMED_9_ADM7154_I249_REF: C518.2(N2) U14.5 U14.6
UNNAMED_9_ADM7154_I249_VREG: C514.1 U14.1(VREG)
UNNAMED_9_ADM7154_I278_BYP: C55.1 U13.3
UNNAMED_9_ADM7154_I278_REF: C510.2(N2) U13.5 U13.6
UNNAMED_9_ADM7154_I278_VREG: C51.1 U13.1(VREG)
UNNAMED_9_ADP176X_I287_PG: R24.2(N2) U2.15
UNNAMED_9_ADP176X_I287_REFCAP: C25.1 U2.5
UNNAMED_9_ADP176X_I287_SS: C22.1 U2.14
UNNAMED_9_ADP176X_I287_VREG: C30.1 U2.6(VREG)
UNNAMED_9_ADP176X_I303_PG: R25.2(N2) U3.15
UNNAMED_9_ADP176X_I303_REFCAP: C27.1 U3.5
UNNAMED_9_ADP176X_I303_SS: C24.1 U3.14
UNNAMED_9_ADP176X_I303_VREG: C40.1 U3.6(VREG)
UNNAMED_9_CAPP_I31_N2: C526.N(N2) R27.1
UNNAMED_10_CAP_I3_N1: C64.1 U8.26
UNNAMED_10_CAP_I4_N1: C60.1 U8.27
UNNAMED_10_CAP_I5_N1: C67.1 U8.28
UNNAMED_10_CAP_I7_N1: C57.1 R54.2(N2) U8.23
UNNAMED_10_DIOLED_I29_P: DS1.A(P) R327.2(N2)
UNNAMED_10_LINLTC2928_I1_DONEN: R53.2(N2) U8.18
UNNAMED_10_LINLTC2928_I1_EN1: Q2.2 U8.2
UNNAMED_10_LINLTC2928_I1_EN2: Q3.2 U8.37
UNNAMED_10_LINLTC2928_I1_EN3: Q4.2 U8.31
UNNAMED_10_LINLTC2928_I1_ON: R68.2(N2) R70.1 R71.1 U8.16
UNNAMED_10_LINLTC2928_I1_OVA: R55.1 R76.1 U8.1
UNNAMED_10_LINLTC2928_I1_RT1: R56.1 U8.6
UNNAMED_10_LINLTC2928_I1_RT2: R58.1 U8.7
UNNAMED_10_LINLTC2928_I1_RT3: R57.1 U8.8
UNNAMED_10_LINLTC2928_I1_SQT1: R77.2(N2) R78.1 U8.10
UNNAMED_10_LINLTC2928_I1_SQT2: R79.2(N2) R80.1 U8.11
UNNAMED_10_LINLTC2928_I1_V1: R74.2(N2) R75.1 U8.3
UNNAMED_10_LINLTC2928_I1_V2: R66.2(N2) R67.1 U8.38
UNNAMED_10_LINLTC2928_I1_V3: R59.2(N2) R60.1 U8.32
UNNAMED_10_RES_I26_N1: Q2.3 Q2.PAD2 R50.1 R337.1 R338.1 R339.1
UNNAMED_10_TRANNMOSFET2PAD_I17_: Q4.5 Q4.6 Q4.PAD1 R29.2(N2)
UNNAMED_10_TRANNMOSFET2PAD_I21_: Q3.5 Q3.6 Q3.PAD1 R40.2(N2)
UNNAMED_10_TRANNMOSFET2PAD_I24_: Q2.5 Q2.6 Q2.PAD1 R30.2(N2)
USB_D+: U20.13 XP2.3
USB_D-: U20.12 XP2.2
USB_VCC: R9.1 R10.2(N2) XP2.1
VADJ: C71.1 C72.1 P1.E39 P1.F40 P1.G39 P1.H40 P1.J39 P1.K40 R72.1 R73.1 U21.1 U21.2 U21.7 U21.15 U22.1 U22.2 U22.7 U22.10 U22.15
VNEG12: C8.2(N2) C531.2(N2) C533.2(N2) C534.2(N2) C536.2(N2) C537.2(N2) C543.2(N2) C549.2(N2) C566.N(N2) R7.2(N2) R445.2(N2) TP43.1(N1) U1.A2 U1.A4 U1.A9 U1.B5 U1.B8 U1.B13 U1.C6 U1.C7
VNEG12_EN: R337.2(N2) U12.5
VOUT: C432.2(N2) R74.1 R445.1 U12.1 U12.2
VREG: C410.2(N2) R48.2(N2) R49.2(N2) R414.1 R416.2(N2) U10.45(VREG)
VTUNE: C69.2(N2) R64.2(N2) U15.20

Pads without a net: NOREF#28 1; NOREF#29 1; P1 A2 A3 A6 A7 A10 A11 A14 A15 A18 A19 B1 B4 B5 B8 B9 B12 B13 B16 B17 B20 B21 B24 B25 B28 B29 B40 C6 C7 C10 C11 C14 C15 C18 C19 C22 C23 C26 C27 C39 D13 D17 D18 D20 D21 D23 D24 D26 D27 D29 D33 D34 D36 D38 D40 E2 E3 E6 E7 E9 E10 E12 E13 E15 E16 E18 E19 E21 E22 E24 E25 E27 E28 E30 E31 E33 E34 E36 E37 F1 F4 F5 F7 F8 F10 F11 F13 F14 F16 F17 F19 F20 F22 F23 F25 F26 F28 F29 F31 F32 F34 F35 F37 F38 G2 G3 G6 G7 G12 G13 G15 G16 G18 G19 G21 G22 G24 G25 G27 G28 G30 G31 G33 G34 G36 G37 H1 H4 H5 H14 H16 H17 H19 H20 H22 H23 H25 H26 H28 H29 H31 H32 H34 H35 H37 H38 J2 J3 J6 J7 J9 J10 J12 J13 J15 J16 J18 J19 J21 J22 J24 J25 J27 J28 J30 J31 J33 J34 J36 J37 K1 K4 K5 K7 K8 K10 K11 K13 K14 K16 K17 K19 K20 K22 K23 K25 K26 K28 K29 K31 K32 K34 K35 K37 K38; T33 1 5; U1 J4 J5 K5 K9 L7; U2 8; U3 8; U4 4; U5 4 6 7 8 13 14 15 16; U7 4 7 8 9 10 15; U8 4 15 17 20 21 29 33 34 35 36; U9 2 6; U11 5 14 15 16; U16 3 4 5 6 9 10; U20 1 2 22 23 27; XP1 4; XP2 4; Y61 1 2

## Via types
v1: diameter 0.356, hole 0.127, TOP to BOTTOM, 145 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 342 vias
v3: diameter 0.508, hole 0.254, L2_GROUND to L11_GROUND, 9 vias
v4: diameter 0.381, hole 0.203, L11_GROUND to BOTTOM, 65 vias
v5: diameter 0.635, hole 0.305, TOP to BOTTOM, 337 vias
v6: diameter 0.381, hole 0.203, TOP to L2_GROUND, 127 vias
v7: diameter 0.66, hole 0.406, TOP to BOTTOM, 8 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
GND: length 618
  TOP w0.203: 37.24,41.62 39.17,41.62 39.2,41.59 39.98,41.59 40.18,41.39
  TOP w0.254: v1(28.63,36.09) v1(28.63,36.89) ; v1(28.63,36.89) v1(29.43,36.89) ; v1(28.63,36.89) v1(28.63,37.69) v1(29.43,37.69) v1(29.43,38.49) ; U1.J6 v1(32.63,39.29) v1(33.43,39.29) v1(34.23,39.29) v1(35.03,39.29) v1(35.03,40.09) ; v2(18.36,25.69) 18.63,25.95 ; U17.4 39.36,8.1 v6(38.61,8.85) ; 22.76,13.65 U15.8 ; 22.76,13.65 v6(23.24,13.17) v6(24.51,11.9) ; 22.76,13.65 U15.9 ; v6(21.97,57.49) v6(21.46,56.98) 21.21,56.73 U2.7 ; C311.1 v6(21.84,21.93) ; v6(24.51,11.9) 25.76,13.15 U15.31 ; v6(24.51,11.9) 24.26,11.65 ; v6(24.51,11.9) 24.76,11.65 U15.21 ; R311.1 v5(42.29,7.07) ; C654.2 v2(18.22,19.58) ; v1(27.03,43.29) v1(27.03,44.09) v1(27.03,44.89) ; 37.87,43.14 40.74,43.14 ; C637.2 v6(26.86,7.52) ; v6(14.99,24.85) 15.18,24.65 U5.11 ; v1(26.23,36.09) v1(26.23,36.89) U1.C3 v1(27.03,37.69) ; v1(26.23,36.09) v1(27.03,36.09) ; v1(26.23,36.09) v1(25.43,35.29) ; 24.26,11.65 23.26,10.65 U15.18 ; 24.26,11.65 U15.13 ; v5(56.13,47.97) 56.79,47.31 U21.10 ; v1(34.23,36.09) v1(33.43,36.09) v1(33.43,35.29) ; v1(34.23,36.09) v1(35.03,36.09) ; v1(34.23,36.09) v1(34.23,35.29) ; C314.2 v6(20.95,21.93) ; Q2.1 v6(5.21,63.21) ; v1(28.63,44.89) v1(29.43,44.89) v1(30.23,44.89) v1(30.23,44.09) ; v6(66.55,42.25) 66.8,42.5 U22.8 ; v6(14.73,18.38) 14.48,18.63 U16.14 ; Q4.4 v6(15.45,65.03) ; C328.2 C327.2 43.88,13.36 v5(43.69,13.55) ; Q3.1 9.52,63.21 9.14,63.59 v6(9.14,63.84) ; v5(44.96,4.53) 45.21,4.79 R310.1 ; v6(30.99,56.98) 30.74,56.73 U3.7 ; U1.F6 v1(29.43,40.09) ; v1(29.43,40.09) v1(28.63,40.09) v1(27.83,40.09) v1(27.83,39.29) ; v1(29.43,40.09) v1(29.43,40.89) ; Q2.4 v6(7.32,65.03) ; v1(28.63,44.09) v1(28.63,43.29) v1(28.63,42.49) U1.F10 U1.F11 ; v1(35.03,37.69) v1(34.23,37.69) ; v1(35.03,44.09) v1(34.23,44.09) v1(34.23,44.89) ; U18.4 11.82,10.11 v6(12.57,9.36) ; 14.99,18.12 15.49,18.63 U16.7 ; U1.N10 v1(34.23,42.49) ; U5.10 v6(15.04,25.3) ; v1(30.23,35.29) v1(30.23,36.09) ; U1.J8 v1(31.83,40.09) U1.H7 ; R618.2 v6(24.64,6.69) ; U21.PAD 59.43,46.31 U21.8 ; Q4.1 v6(13.34,63.21) ; v1(31.83,35.29) 31.83,35.31 31.83,35.32 31.83,35.34 32.02,35.52 32.02,35.81 31.91,35.92 31.8,36.03 31.83,36.06 v1(31.83,36.09) ; v1(35.03,40.89) v1(34.23,40.89) v1(33.43,40.89) ; C339.2 v6(34.92,6.82) ; 39.07,39.18 40.34,39.18 ; Q3.4 v6(11.51,65.03)
  TOP w0.305: v5(5.77,56.35) 6.73,57.31 C56.2 ; v5(51.37,13.49) C330.2 C331.2 ; v6(21.4,16.66) C619.2 C618.2 ; v2(20.37,25.93) 20.95,25.93 ; v6(9.78,57.87) 10.53,57.12 U13.4 ; U20.16 50.26,58.99 U20.PAD 50.91,60.94 U20.5 ; R328.1 v5(49.15,2.37) ; 10.41,21.61 v5(10.41,21.93) ; v6(72.64,57.24) 72.46,57.05 U23.7 ; U23.4 v5(71.16,62.66) ; R88.1 v5(71.12,64.86) ; C643.2 v6(22.54,7.39) C636.2 ; C655.2 v5(10.67,19.14) ; 18.79,25.3 18.59,25.51 18.19,25.51 v2(17.65,24.98)
  TOP w0.33: XP1.6 62.45,65.53 ; XP1.6 60.74,67.23 ; XP1.6 60.74,65.53 ; XP1.6 62.45,67.23 ; 18.53,21.69 TP42.1 ; TP42.1 20.59,21.69 ; TP42.1 18.53,19.63 ; TP42.1 20.59,19.63 ; 70.21,2.46 TP64.1 ; TP64.1 70.21,4.07 ; TP64.1 71.82,2.46 ; TP64.1 71.82,4.07 ; 47,63.11 XP2.G1 45.17,63.11 ; v2(9.27,21.93) 9.59,21.61 R623.2
  TOP w0.508: R69.1 v5(29.59,14.69) ; v6(9.27,50.89) 9.91,51.52 C513.1 ; v5(59.56,37.81) 59.44,37.81 59.18,38.06 R17.2 ; J62.2 v5(2.15,15.59) ; J62.2 U19.PAD ; J62.2 v5(2.15,7.06) ; C669.1 v5(11.86,14.91) ; 35.56,9.27 36.28,9.27 v6(37.08,8.47) ; 37.59,22.11 36.88,22.11 v5(36.32,21.55) ; J61.3 v5(34.79,16.05) ; v6(1.91,50.63) 1.91,50 2.29,49.62 L3.2 ; C429.1 52.45,48.35 v2(52.45,48.73) ; v5(36.23,57.4) 36.23,56.77 35.81,56.35 ; C55.2 12.83,58.25 v5(12.07,59.02) ; R417.1 v5(51.31,2.37) ; v5(42.67,12.91) 42.72,12.86 C326.2 ; D1.A v5(57.9,3.4) ; v6(12.57,9.36) v6(13.34,9.36) ; 13.34,4.32 C663.1 v5(12.61,4.32) ; v5(38.61,52.54) C567.2 37.14,52.61 37.14,54.11 v5(37.63,54.61) ; C656.1 36.07,2.75 v5(36.2,2.63) ; C30.2 v5(16.29,55.88) ; v5(59.31,3.26) C548.N v5(60.71,2.12) ; v5(25.27,2.5) U9.8 26.66,2.5 ; C510.1 v6(15.86,61.61) ; v6(14.73,18.38) 14.99,18.12 ; J61.2 v5(29.17,22.38) ; v5(7.44,15.4) 7.76,15.09 J62.3 ; 75.18,59.78 v5(74.68,59.78) ; L3.2 v6(2.79,50.76) ; L3.2 3.3,49.62 3.81,50.13 v6(3.81,50.63) ; C666.1 9.78,6.56 v5(9.78,7.33) ; v5(57.28,41.11) 56.39,42 C76.2 ; L4.2 2.29,28.92 1.91,28.54 v5(1.91,27.77) ; L4.2 3.3,28.92 3.81,28.41 v5(3.81,27.77) ; L4.2 v5(2.79,27.77) ; R27.2 v5(18.03,51.4) ; R617.2 30.1,8.85 v6(30.61,8.85) ; U4.2 v5(33.66,64.6) ; C51.2 v6(7.75,50.89) ; 25.91,56.6 v5(25.91,57.36) 25.91,58 26.45,58.55 C27.2 ; 33.53,10.34 v6(33.53,11.14) ; 17.4,4.79 v5(17.4,3.9) ; 44.83,22.06 45.09,21.8 C65.1 46.06,21.26 46.1,21.3 46.61,20.79 C63.1 ; v5(29.21,66.51) 30.14,65.58 C9.2 ; C660.1 v5(10.29,12.28) ; C325.1 v5(52.67,11.3) ; R330.2 v5(49.78,4.41) ; C52.2 28.87,54.41 v5(28.57,54.7) 28.07,55.21 C40.2 ; v5(30.61,24.98) 30.99,24.6 C7.2 ; R621.1 v5(26.04,21.27) ; C23.2 v5(20.32,45.55) ; C29.2 v5(28,60.29) ; v2(61.26,40.78) 61.96,41.49 C72.2 ; 66.29,47.08 v6(66.29,47.59) ; C649.1 v5(11.18,16.47) ; C665.1 v5(41.15,12.15) ; C659.1 v6(40.42,8.85) ; R3.2 v5(35.81,25.87) ; v5(59.18,45.43) U21.PAD ; C668.1 v5(38.35,3.14)
  L2_GROUND w0.33: XP1.6 62.45,67.23 ; XP1.6 60.74,67.23 ; XP1.6 62.45,65.53 ; XP1.6 60.74,65.53 ; XP2.G1 47,60.09 ; XP2.G1 47,63.11 ; XP2.G1 45.17,63.11 ; TP42.1 20.59,21.69 ; TP42.1 18.53,19.63 ; TP42.1 20.59,19.63 ; TP42.1 18.53,21.69 ; 70.21,4.07 TP64.1 ; TP64.1 70.21,2.46 ; TP64.1 71.82,2.46 ; TP64.1 71.82,4.07 ; 41.67,58.19 XP2.G2 41.67,61.21 ; XP2.G3 47,58.91 ; XP2.G3 47,55.69 ; XP2.G3 45.17,58.91 ; XP2.G3 45.17,55.69 ; 44.21,57.48 XP2.5 45.46,58.73
  L2_GROUND w0.508: XP2.G1 46.08,63.31 46.1,63.33 ; XP2.G3 46.08,55.61 46.1,55.59
  L3_SIGNAL w0.33: TP42.1 20.59,19.63 ; TP42.1 18.53,21.69 ; TP42.1 20.59,21.69 ; TP42.1 18.53,19.63 ; 60.74,67.23 XP1.6 ; XP1.6 62.45,67.23 ; XP1.6 62.45,65.53 ; XP1.6 60.74,65.53 ; 44.21,57.48 XP2.5 45.46,58.73 ; 45.17,63.11 XP2.G1 ; XP2.G1 47,63.11 ; XP2.G1 47,60.09 ; 70.21,4.07 TP64.1 ; TP64.1 70.21,2.46 ; TP64.1 71.82,2.46 ; TP64.1 71.82,4.07 ; 41.67,58.19 XP2.G2 41.67,61.21
  L4_GROUND w0.33: TP42.1 20.59,21.69 ; TP42.1 18.53,19.63 ; TP42.1 20.59,19.63 ; TP42.1 18.53,21.69 ; 41.67,58.19 XP2.G2 41.67,61.21 ; XP1.6 62.45,67.23 ; XP1.6 62.45,65.53 ; XP1.6 60.74,65.53 ; XP1.6 60.74,67.23 ; 45.17,63.11 XP2.G1 ; XP2.G1 47,63.11 ; XP2.G1 47,60.09 ; XP2.G3 47,55.69 ; XP2.G3 47,58.91 ; XP2.G3 45.17,55.69 ; XP2.G3 45.17,58.91 ; 70.21,4.07 TP64.1 ; TP64.1 71.82,4.07 ; TP64.1 70.21,2.46 ; TP64.1 71.82,2.46 ; 44.21,57.48 XP2.5 45.46,58.73
  L6_POWER w0.33: 18.53,19.63 TP42.1 ; TP42.1 20.59,19.63 ; TP42.1 18.53,21.69 ; TP42.1 20.59,21.69
  L6_POWER w0.508: 33.96,60.87 34.16,61.07 v5(34.16,61.68)
  L7_GROUND w0.33: 18.53,19.63 TP42.1 ; TP42.1 20.59,21.69 ; TP42.1 20.59,19.63 ; TP42.1 18.53,21.69 ; 45.17,63.11 XP2.G1 ; XP2.G1 47,63.11 ; XP2.G1 47,60.09 ; TP64.1 71.82,2.46 ; TP64.1 70.21,2.46 ; TP64.1 70.21,4.07 ; TP64.1 71.82,4.07 ; XP1.6 62.45,67.23 ; XP1.6 62.45,65.53 ; XP1.6 60.74,67.23 ; XP1.6 60.74,65.53 ; 45.17,58.91 XP2.G3 ; XP2.G3 47,58.91 ; XP2.G3 45.17,55.69 ; XP2.G3 47,55.69 ; 44.21,57.48 XP2.5 45.46,58.73 ; 41.67,61.21 XP2.G2 41.67,58.19
  L9_GROUND w0.33: 18.53,21.69 TP42.1 ; TP42.1 20.59,19.63 ; TP42.1 18.53,19.63 ; TP42.1 20.59,21.69 ; TP64.1 71.82,2.46 ; TP64.1 70.21,4.07 ; TP64.1 71.82,4.07 ; TP64.1 70.21,2.46 ; XP1.6 62.45,65.53 ; XP1.6 62.45,67.23 ; XP1.6 60.74,67.23 ; XP1.6 60.74,65.53 ; 41.67,61.21 XP2.G2 41.67,58.19 ; XP2.G1 47,60.09 ; XP2.G1 45.17,63.11 ; XP2.G1 47,63.11 ; 45.17,58.91 XP2.G3 ; XP2.G3 45.17,55.69 ; XP2.G3 47,58.91 ; XP2.G3 47,55.69 ; 44.21,57.48 XP2.5 45.46,58.73
  L10_SIGNAL w0.33: 18.53,19.63 TP42.1 ; TP42.1 18.53,21.69 ; TP42.1 20.59,21.69 ; TP42.1 20.59,19.63 ; XP2.G3 47,55.69 ; XP2.G3 47,58.91 ; XP2.G3 45.17,55.69 ; XP1.6 62.45,67.23 ; XP1.6 60.74,67.23 ; XP1.6 62.45,65.53 ; XP1.6 60.74,65.53 ; 44.21,57.48 XP2.5 45.46,58.73 ; 41.67,58.19 XP2.G2 41.67,61.21 ; TP64.1 71.82,4.07 ; TP64.1 70.21,4.07 ; TP64.1 71.82,2.46 ; TP64.1 70.21,2.46
  L11_GROUND w0.33: 70.21,4.07 TP64.1 ; TP64.1 70.21,2.46 ; TP64.1 71.82,2.46 ; TP64.1 71.82,4.07 ; XP2.G3 47,55.69 ; XP2.G3 45.17,55.69 ; XP2.G3 47,58.91 ; XP2.G3 45.17,58.91 ; XP2.G1 47,60.09 ; XP2.G1 47,63.11 ; XP2.G1 45.17,63.11 ; 18.53,21.69 TP42.1 ; TP42.1 20.59,21.69 ; TP42.1 20.59,19.63 ; TP42.1 18.53,19.63 ; XP1.6 62.45,65.53 ; XP1.6 60.74,67.23 ; XP1.6 62.45,67.23 ; XP1.6 60.74,65.53 ; 44.21,57.48 XP2.5 45.46,58.73 ; 41.67,61.21 XP2.G2 41.67,58.19
  BOTTOM w0.254: P1.G4 v2(65.07,54.75) ; v1(27.83,35.29) 27.83,35.44 C539.2 ; P1.D28 v2(68.88,24.27) ; P1.J5 v2(62.53,53.48) ; v1(34.23,37.69) 33.96,37.96 C31.2 ; P1.B14 v2(71.42,42.05) ; C20.2 33.24,43.91 v1(33.43,44.09) ; P1.C21 v2(70.15,33.16) ; P1.D6 v2(68.88,52.21) ; P1.J40 v2(62.53,9.03) ; P1.C25 v2(70.15,28.08) ; P1.G20 v2(65.07,34.43) ; v5(37.47,62.44) 36.71,61.69 U14.4 ; U6.4 29.09,8.1 v4(29.84,8.85) ; C545.2 27.09,44.89 v1(27.03,44.89) ; P1.J17 v2(62.53,38.24) P1.K18 ; v1(31.83,44.09) 31.83,44.02 C532.1 C535.1 ; P1.G29 v2(65.07,23) ; U12.6 v4(19.94,60.16) ; C558.2 25.44,43.29 v1(25.43,43.29) ; U8.9 8.61,56.37 U8.PAD ; P1.B19 v2(71.42,35.7) ; P1.D19 v2(68.88,35.7) ; P1.B15 v2(71.42,40.78) ; P1.C29 v2(70.15,24.27) P1.C28 ; P1.G1 v2(65.07,58.56) ; P1.A25 v2(72.69,28.08) ; P1.F21 v2(66.34,33.16) ; P1.J20 v2(62.53,34.43) P1.K21 ; P1.K9 v2(61.26,48.4) ; 44.73,27.93 44.23,27.43 U10.11 ; 44.73,27.93 45.59,28.79 ; 44.73,27.93 U10.10 ; P1.F9 v2(66.34,48.4) ; v5(12.07,59.02) 12.11,59.06 U8.30 ; P1.A9 v2(72.69,48.4) ; C3.2 30.92,39.9 31.12,40.09 v1(31.83,40.09) ; P1.E1 v2(67.61,58.56) ; P1.F39 v2(66.34,10.3) ; C544.2 29.53,41.59 v1(29.43,41.69) ; P1.H9 v2(63.8,48.4) ; P1.A33 v2(72.69,17.92) ; P1.B18 v2(71.42,36.97) ; P1.J1 v2(62.53,58.56) ; P1.C20 v2(70.15,34.43) ; P1.A24 v2(72.69,29.35) ; P1.E5 v2(67.61,53.48) ; v5(45.34,38.19) 45.58,37.95 Q1.4 ; Q1.1 v5(47.27,35.88) ; P1.E29 v2(67.61,23) ; P1.E4 v2(67.61,54.75) ; P1.A29 v2(72.69,23) ; P1.E40 v2(67.61,9.03) ; C554.2 32.08,44.89 32.07,44.89 v1(31.83,44.89) ; P1.K24 v2(61.26,29.35) ; P1.A28 v2(72.69,24.27) ; v1(34.23,42.49) 34.11,42.6 34.11,42.75 34.01,42.86 C43.2 ; P1.A21 v2(72.69,33.16) ; P1.K15 v2(61.26,40.78) ; v1(31.83,36.09) 31.95,36.22 C541.1 ; C538.2 28.57,42.44 v1(28.63,42.49) ; P1.F24 v2(66.34,29.35) ; P1.D25 v2(68.88,28.08) ; v4(53.34,46.32) 53.59,46.57 U11.10 ; P1.H24 v2(63.8,29.35) ; P1.K6 v2(61.26,52.21) ; P1.F6 v2(66.34,52.21) ; P1.A13 v2(72.69,43.32) ; P1.J29 v2(62.53,23) ; P1.A16 v2(72.69,39.51) ; P1.C24 v2(70.15,29.35) ; P1.A17 v2(72.69,38.24) ; P1.B7 v2(71.42,50.94) ; P1.H6 v2(63.8,52.21) ; P1.A20 v2(72.69,34.43) ; P1.H21 v2(63.8,33.16) ; P1.A12 v2(72.69,44.59) ; P1.G40 v2(65.07,9.03) ; P1.D7 v2(68.88,50.94) ; C2.2 29.48,38.49 v1(29.43,38.49) ; P1.A8 v2(72.69,49.67) ; P1.E20 v2(67.61,34.43)
  BOTTOM w0.305: v4(27.56,9.99) C614.2 C616.2 ; U19.4 2.17,10.89 U19.PAD ; C648.2 v4(24.57,8.02) ; 48.23,27.93 48.73,27.43 U10.2 ; 48.23,27.93 v4(46.48,29.68) 46.23,29.93 U10.30 ; 48.23,27.93 U10.3 ; C622.2 v4(26.61,9.04) ; XP2.5 44.81,58.1 43.87,57.16 ; C620.2 v4(26.61,7.9) ; U8.13 6,56.12 v5(5.77,56.35) 6.04,56.62 U8.14 ; U8.PAD 9.11,58.37 U8.24 ; C612.2 v4(27.56,13.3) ; C617.2 v4(27.56,12.53) ; U8.12 v5(6.48,55.17)
  BOTTOM w0.33: TP64.1 71.82,2.46 ; TP64.1 70.21,2.46 ; TP64.1 71.82,4.07 ; TP64.1 70.21,4.07 ; 45.17,63.11 XP2.G1 47,63.11 ; 18.53,19.63 TP42.1 ; TP42.1 20.59,21.69 ; TP42.1 20.59,19.63 ; TP42.1 18.53,21.69 ; 60.74,65.53 XP1.6 ; XP1.6 60.74,67.23 ; XP1.6 62.45,67.23 ; XP1.6 62.45,65.53
  BOTTOM w0.508: C515.2 v5(36.23,57.4) ; C410.1 v5(56.01,27.52) C411.1 R413.2 ; C661.1 v4(1.02,8.22) ; C426.2 23.41,57.78 v4(23.5,57.87) ; C42.1 v4(40.32,37.11) ; 34.54,4.28 v4(34.92,4.28) ; C66.1 v4(18.92,9.74) ; v5(33.66,64.6) 34.58,65.53 C518.1 ; R80.2 v5(4.19,51.14) ; v5(35.81,25.87) 35.56,26.12 35.56,27.01 ; 45.59,28.79 v4(46.48,29.68) ; v4(46.48,29.68) 44.32,30.06 ; v4(46.48,29.68) 44.96,29.42 ; v4(46.48,29.68) 45.47,28.92 ; C312.1 v5(29.08,4.02) ; C437.2 v4(58.93,51.14) ; R9.2 v5(46.48,53.55) ; C664.1 7.3,15.54 v5(7.44,15.4) ; v5(30.31,3.81) C317.1 C310.1 ; C48.1 38.28,34 v4(38.66,33.62) ; v5(29.59,14.69) 30.1,14.18 C313.1 ; C667.1 v5(3.81,15.45) ; R436.2 R429.1 v5(49.53,51.27) ; C657.1 15.46,14.02 v5(16,14.57) ; R41.1 v5(36.83,29.47) ; C424.1 v5(40.89,52.04) ; C419.1 32.94,20.67 v5(33.95,20.67) ; v5(45.85,15.58) 46.09,15.34 FL1.5 ; R78.2 v5(6.48,51.14) ; L45.1 47.31,48.67 ; 47.31,48.67 48.33,48.67 ; 47.31,48.67 47.62,48.98 v5(47.62,49.49) ; XC12.1 v4(49.91,63.21) ; C444.1 36.35,20.03 v5(36.22,20.15) ; 48.33,48.67 48.64,48.98 v5(48.64,49.49) ; 48.33,48.67 v5(49.66,48.67) ; C61.1 v4(20.07,13.42) ; C69.1 17.27,6.82 ; C566.P v5(22.23,47.9) ; v5(56.78,34.63) 56.39,34.63 56.26,34.5 C41.1 ; XC6.2 50,60.63 v5(50.04,60.67) ; C46.1 v5(38.7,25.53) ; v4(23.62,56.48) 23.2,56.06 C432.1 ; R1.2 v5(37.21,45.76) ; C522.1 v5(37.47,56.73) ; v5(58.04,16.72) 58.04,17.61 ; U19.PAD 3.81,12.03 ; C427.1 v5(20.07,63.33) ; C651.1 v4(25.95,4.95) ; C47.1 v5(54.48,32.73) ; v4(17.53,15.2) R61.1 v4(18.41,14.69) ; C49.1 v5(56.77,27.14) ; FL1.3 v4(49.08,5.35) ; C645.1 v5(28.19,5.55) ; C436.2 v4(55.88,51.14) ; C315.1 v4(28.57,13.55) ; FL1.6 v5(54.66,13.37) ; C670.1 v5(3.85,6.35) ; C430.1 v5(58.93,46.19) ; P1.G14 P1.H15 ; R42.2 v5(39.62,24.98) ; R76.2 16.45,54.68 17.13,54.68 v5(17.4,54.95) ; 12.45,63.21 v4(13.34,63.21) ; C435.2 v4(18.16,54.82) ; XC4.N v5(57.91,64.22) ; C658.1 v4(5.55,11.86)
  vias: v1(27.03,42.49) v1(33.43,44.89) v1(70.78,14.75) v2(3.56,23.07) v2(3.56,20.53) v2(4.45,15.96) v2(4.7,23.07) v2(5.08,20.53) v2(5.21,17.74) v2(5.59,23.96) v2(5.72,19.26) v2(6.48,24.85) v2(6.48,20.15) v2(6.99,21.8) v2(7.37,21.04) v2(7.49,25.87) v2(7.62,16.6) v2(7.75,17.61) v2(8.13,22.95) v2(8.13,21.8) v2(8.38,18.5) v2(8.64,26.88) v2(9.02,23.71) v2(9.02,19.14) v2(9.65,19.77) v2(10.03,27.14) v2(10.16,24.34) v2(11.3,27.14) v2(11.56,24.34) v2(12.83,24.34) v2(16.94,25.69) v2(16.94,24.98) v2(16.94,24.27) v2(17.65,25.69) v2(17.65,24.27) v2(18.36,24.98) v2(18.36,24.27) v2(26.1,32.52) v2(26.99,32.52) v2(34.29,2.75) v2(34.29,1.23) v2(35.56,0.72) v2(37.21,0.72) v2(37.34,2.12) v2(38.35,2.12) v2(38.35,0.72) v2(39.24,2.12) v2(39.24,0.72) v2(40.26,2.12) v2(40.39,0.72) v2(41.53,0.72) v2(43.43,0.72) v2(44.12,65.64) v2(44.07,30.06) v2(44.7,29.42) v2(44.83,0.72) v2(45.09,32.09) v2(45.34,28.79) v2(45.57,64.96) v2(45.72,31.46) v2(45.97,28.15) v2(46.23,0.72) v2(46.48,30.69) v2(47.24,29.93) v2(47.5,0.85) v2(47.88,31.96) v2(47.88,29.3) v2(48.39,31.33) v2(48.51,28.66) v2(49.02,30.69) v2(49.35,64.98) v2(50.16,61.68) v2(51.69,61.68) v2(52.83,61.68) v2(54.1,43.65) v3(41.02,29.42) v4(19.72,15.62) v4(20.13,10.18) v4(22.86,11.39) v4(24.38,12.79) v4(29.08,9.49) v4(29.08,8.85) v4(29.08,8.22) v4(29.84,9.49) v4(29.84,8.22) v4(30.73,9.49) v4(30.73,8.85) v4(30.73,8.22) v4(34.92,13.3) v4(35.69,8.47) v4(39.24,11.77) v4(44.32,31.96) v4(44.32,30.95) v4(44.32,28.54) v4(44.32,27.27) v4(46.48,31.96) v4(46.48,27.27) v4(48.64,29.68) v4(48.64,27.27) v4(50.29,54.32) v4(50.93,54.32) v4(51.56,54.32) v4(52.83,27.65) v4(56.39,55.59) v4(56.39,53.55) v4(65.66,42.63) v5(0.94,26.95) v5(0.94,25.17) v5(0.94,18.44) v5(0.94,16.66) v5(2.21,26.95) v5(2.21,25.17) v5(2.21,18.44) v5(2.21,16.66) v5(2.16,12.03) v5(2.16,11.26) v5(2.92,12.03) v5(2.92,11.26) v5(3.48,26.95) v5(3.48,25.17) v5(3.48,18.44) v5(3.48,16.66) v5(4.7,46.57) v5(4.75,26.95) v5(4.75,25.17) v5(4.75,18.44) v5(4.75,16.66) v5(4.83,31.96) v5(6.1,50.25) v5(6.6,43.65) v5(7.24,28.66) v5(10.29,28.41) v5(11.94,45.3) v5(12.32,47.97) v5(13.59,12.03) v5(14.1,59.78) v5(15.37,45.17) v5(15.62,7.45) v5(17.14,46.95) v5(17.78,16.85) v5(18.29,47.71) v5(18.29,45.3) v5(19.69,48.09) v5(20.23,3.81) v5(22.61,3.77) v5(23.45,19.2) v5(23.88,43.9) v5(24.26,28.15) v5(24.26,27.27) v5(24.26,26.38) v5(24.38,34) v5(24.38,33.11) v5(24.38,32.22) v5(24.38,31.46) v5(25.15,26.38) v5(25.78,22.82) v5(25.91,26.38) v5(26.92,47.46) v5(26.92,26.38) v5(27.43,23.24) v5(27.81,26.38) v5(28.83,32.22) v5(28.83,31.33) v5(28.83,30.44) v5(28.83,29.55) v5(28.83,28.66) v5(28.83,27.9) v5(28.83,27.14) v5(28.83,26.38) v5(29.72,1.87) v5(32.13,1.36) v5(34.8,46.92) v5(35.18,54.95) v5(36.58,62.44) v5(37.57,46.98) v5(39.92,56.01) v5(40.35,6.09) v5(41.02,60.16) v5(42.67,56.6) v5(42.67,25.36) v5(42.93,61.94) v5(44.45,56.6) v5(45.59,51.01) v5(46.1,40.98) v5(47.12,39.97) v5(51.54,40.79) v5(51.94,60.67) v5(52.7,13.04) v5(53.47,20.53) v5(54.99,22.26) v5(58.67,40.35) v5(58.67,28.41) v5(58.8,24.98) v5(59.31,46.7) v5(59.36,17.87) v5(62.99,4.02) v5(65.15,62.57) v5(66.67,6.06) v5(68.33,5.55) v5(70.36,7.83) v5(70.48,5.55) v5(70.74,67.27) v5(73.28,6.69) v5(73.41,64.86) v5(74.83,62.95) v5(74.83,4.53) v5(75.44,64.86) v6(9.02,58.38) v6(9.02,57.87) v6(9.02,57.36) v6(9.78,58.38) v6(9.78,57.36) v6(10.54,58.38) v6(10.54,57.87) v6(10.54,57.36) v6(11.81,9.99) v6(11.81,9.36) v6(11.81,8.72) v6(12.57,9.99) v6(12.57,8.72) v6(12.76,15.71) v6(13.34,9.99) v6(13.34,8.72) v6(14.22,18.88) v6(14.22,17.99) v6(15.11,18.88) v6(15.11,17.99) v6(15.56,15.71) v6(15.62,13.68) v6(16.38,59.02) v6(16.38,13.61) v6(20.95,57.49) v6(20.95,56.98) v6(20.95,56.48) v6(21.08,3.58) v6(21.46,57.49) v6(21.46,56.48) v6(21.84,3.58) v6(21.97,56.98) v6(21.97,56.48) v6(23.24,11.9) v6(23.24,10.63) v6(23.56,17.17) v6(23.62,3.58) v6(24.51,13.17) v6(24.51,10.63) v6(24.64,3.58) v6(25.65,13.17) v6(25.65,11.9) v6(25.65,10.63) v6(30.99,57.49) v6(30.99,56.48) v6(31.5,57.49) v6(31.5,56.98) v6(31.5,56.48) v6(32,57.49) v6(32,56.98) v6(32,56.48) v6(36.25,41.06) v6(37.85,9.49) v6(37.85,8.85) v6(37.85,8.22) v6(38.61,9.49) v6(38.61,8.22) v6(39.5,9.49) v6(39.5,8.85) v6(39.5,8.22) v6(40.72,39.2) v6(42.9,37.04) v6(45.21,34.71) v6(46.23,10.25) v6(46.23,9.36) v6(46.23,8.6) v6(47.12,10.25) v6(47.12,9.36) v6(47.12,8.6) v6(47.88,44.16) v6(48.01,10.25) v6(48.01,9.36) v6(48.01,8.6) v6(50.16,58.89) v6(50.16,46.7) v6(50.16,46.06) v6(50.16,45.43) v6(51.44,58.89) v6(52.7,58.89) v6(59.21,12.53) v6(66.55,42.89) v6(66.55,41.62) v6(66.93,38.82) v6(67.56,47.59) v6(70.61,12.63)
SVDD12: length 11
  TOP w0.254: U1.L9 U1.L10 v1(33.43,43.29) ; U1.L4 v1(33.43,36.89) ; v1(31.03,43.29) U1.J11 v1(32.63,43.29) ; U1.H3 v1(31.83,36.89)
  BOTTOM w0.254: v1(31.03,43.29) C535.2 C532.2 32.59,43.33 32.59,43.33 ; C546.2 35.18,35.14 v1(35.03,35.29) ; C20.1 32.76,43.42 v1(32.63,43.29) ; C26.1 34.84,44.89 v1(35.03,44.89) ; C43.1 33.56,42.91 33.45,43.02 33.45,43.27 v1(33.43,43.29) v1(32.63,43.29) ; C554.1 32.59,44.29 32.59,43.33 ; v1(32.63,43.29) 32.59,43.33 ; v1(32.63,36.89) v1(33.43,36.89)
  vias: v1(31.03,40.89) v1(31.03,39.29) v1(32.63,40.89) v1(32.63,40.09) v1(33.43,38.49) v5(32,54.32) v5(32,53.17) v5(33.15,54.32) v5(33.15,53.17)
VCC: length 23.1
  TOP w0.508: v5(25.4,64.95) 25.27,64.95 24.88,64.55 R327.1 ; R40.1 v6(8.31,62.77) ; R50.2 4.83,62.06 v5(4.24,62.65) R30.1 ; R51.2 10.29,61.56 v5(9.61,60.87) ; R29.1 12.62,63.51 v5(13.14,64.03) ; R52.2 v5(16.38,65.24)
  L2_GROUND w0.508: v6(8.31,62.77) 8.31,62.11 v5(7.24,61.05)
  BOTTOM w0.254: U8.25 v5(9.61,60.87) ; U8.22 8.11,60.48 7.79,60.79 7.49,60.79 v5(7.24,61.05) 6.73,61.55 6.73,61.94
  BOTTOM w0.508: R57.2 R58.2 ; R58.2 8.76,51.14 8.51,50.89 v5(8.51,50.63) ; R58.2 R56.2 ; C58.1 6.73,61.94 ; R77.1 v5(5.33,51.14) ; R68.1 v5(2.54,57.49) ; R53.1 v5(2.54,58.63) ; R55.2 16.71,53.25 v5(17.4,53.94) ; R79.1 v5(2.16,52.03) ; R63.1 v5(17.27,62.06)
VDDA12: length 0.9
  TOP w0.254: v1(26.23,43.29) U1.B10
  BOTTOM w0.254: C558.1 26.12,43.29 v1(26.23,43.29)
  vias: v5(22.48,54.57) v5(22.48,53.81) v5(23.11,54.57) v5(23.11,53.81)
VDDA25: length 20.6
  TOP w0.254: v5(9.4,46.06) 9.27,46.19 C33.6 ; 9.53,55.72 9.53,55.71 ; C32.2 9.27,31.96 v2(9.4,31.84) ; v5(6.35,45.17) 6.86,45.68 C33.4 ; 9.53,56.17 9.53,56.18 U13.2 ; v2(6.35,31.08) 6.55,31.28 6.58,31.28 6.76,31.46 C32.8 ; C33.8 8.89,47.2 v5(9.4,47.71) ; v2(9.27,33.11) 9.14,32.98 C32.4 ; C33.2 6.48,46.7 v5(6.35,46.82) ; C32.6 v2(6.35,32.47)
  TOP w0.305: 9.53,55.21 9.53,55.21 9.53,55.72
  TOP w0.508: 14.1,54.82 14.22,54.82 15.11,55.71 15.11,59.65 15.49,60.03 16.89,60.03 v5(17.53,60.67) ; C35.2 v2(9.86,37.93)
  BOTTOM w0.254: C537.1 26.24,37.69 v1(26.23,37.69) ; v1(25.43,42.49) 25.38,42.44 C534.1
  BOTTOM w0.508: C549.1 v5(14.35,49.02) ; v5(17.53,60.67) 17.14,60.29 R59.1
  vias: v1(22.45,43.09) v1(22.45,42.56) v1(22.45,42.1) v1(22.5,37.17) v1(22.5,36.66) v1(22.5,36.26) v1(22.94,42.56) v1(22.94,42.1) v1(22.99,37.17) v1(22.99,36.66) v1(23.37,42.56) v1(23.39,42.1) v1(23.7,37.37) v1(24.41,37.83) v1(25.43,38.49) v1(25.43,36.89) v1(26.23,44.09) v1(26.23,41.69) v1(26.23,40.09) v1(27.03,40.89) v1(27.03,38.49) v2(9.93,39.25) v2(10.79,41.36) v2(10.85,39.23) v2(11.68,41.36) v2(11.76,39.25) v2(12.6,41.36) v2(12.62,39.25) v2(12.7,36.41) v2(13.49,41.36) v2(13.59,39.25) v2(13.77,36.41) v2(14.48,41.36) v2(14.53,39.25) v2(14.71,36.43) v2(15.49,41.39) v2(15.54,39.28) v2(15.62,36.43) v2(16.38,41.62) v2(16.84,36.38) v2(17.27,41.79) v2(17.73,36.38) v2(18.19,41.79) v2(18.62,36.38) v2(19.15,41.82) v2(19.18,41.06) v2(19.18,40.3) v2(19.18,39.41) v2(19.18,38.52) v2(19.18,37.63) v2(19.51,36.38) v2(20.19,41.84) v2(20.37,36.38) v2(21.11,41.87) v2(21.13,36.38) v2(21.92,36.41) v5(9.88,41.34) v5(9.96,36.46) v5(13.34,52.41) v5(13.97,52.67) v5(13.97,51.78)
VDDA25_EN: length 11
  TOP w0.203: U13.7 9.53,59.91 10.03,60.41 11.36,60.41 11.87,60.92 v2(12.38,60.92) ; Q4.PAD2 15.03,63.94 Q4.3 v2(15.62,63.21) 16.33,63.21 R52.1
  L3_SIGNAL w0.203: v2(15.62,63.21) 15.62,62.19 15.24,61.81 13.27,61.81 v2(12.38,60.92)
VDDC12: length 7.3
  TOP w0.254: U1.D10 U1.D11 v1(27.83,44.09) v1(27.83,44.89) ; v1(27.83,38.49) v1(27.83,37.69) U1.D3 v1(27.83,36.09) U1.E1 ; U1.D9 v1(27.83,40.89)
  BOTTOM w0.254: v1(27.83,44.89) 27.78,44.89 C545.1 ; v1(27.83,38.49) 27.72,38.6 C536.1
  BOTTOM w0.305: v1(27.83,40.89) 27.83,40.87 C533.1
  vias: v5(27.3,51.78) v5(27.3,50.89) v5(27.3,49.74) v5(27.3,48.73)
VIN_12V: length 35.3
  TOP w0.508: DS2.A v5(53.76,6.22)
  L3_SIGNAL w0.203: 52.07,13.42 52.07,9.61 53.72,7.96 53.72,6.26 v5(53.76,6.22)
  L3_SIGNAL w0.508: v5(52.73,14.77) 52.73,14.08 52.07,13.42
  BOTTOM w0.254: U10.37 50.25,32.43 v5(50.8,32.98) ; 42.29,32.09 42.63,32.43 ; 42.63,32.43 U10.24 ; 42.63,32.43 42.58,32.43
  BOTTOM w0.305: U10.6 46.73,25.36 46.48,25.11 46.23,25.36 U10.7 ; U10.23 42.45,31.93 42.29,32.09
  BOTTOM w0.508: 41.95,19.91 41.95,20.75 v5(42.02,20.83) ; 41.95,19.91 C45.2 ; 41.95,19.91 C44.2 43.45,20.1 45.97,20.1 46.47,20.61 46.47,21.02 46.48,21.03 46.48,21.36 46.48,21.37 46.48,25.11 ; 40,34.5 39.75,34.76 C42.2 v5(38.47,35.2) ; R428.1 v5(52.7,52.28) ; v2(9.14,64.48) 9.14,63.97 9.02,63.84 R54.1 ; v5(52.73,14.77) 53.28,15.32 FL1.2 52.28,15.96 v5(51.69,15.96)
  vias: v5(51.82,14.95) v5(54.74,44.79)
3P3VAUX: length 1.3
  TOP w0.508: C818.2 v2(74.55,58.51)
  BOTTOM w0.254: v2(69.07,20.27) P1.D32
  vias: v2(74.17,55.84)
