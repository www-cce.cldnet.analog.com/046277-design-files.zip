# Allegro board 08_046277e.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
73_SYNC: length 3.6
  BOTTOM w0.203: U11.4 51.7,47.07 51.5,47.27 51.5,48.54 50.67,49.36 50.67,49.74 R429.2
73_VREF: length 4
  TOP w0.203: C429.2 v2(54.74,47.84)
  BOTTOM w0.203: 54.92,47.08 54.91,47.07 U11.9 ; 54.92,47.08 55.26,47.08 55.53,47.34 55.97,47.34 55.99,47.33 57.15,47.33 R434.2 ; 54.92,47.08 54.74,47.26 v2(54.74,47.84)
73_VREG: length 13.3
  L10_SIGNAL w0.203: v2(50.29,48.09) 51.18,48.09 52.07,47.2 52.07,46.43 54.35,44.16 55.5,44.16 v2(55.75,44.41)
  BOTTOM w0.203: U11.11 55.76,46.07 55.91,46.21 56.6,46.21 56.63,46.19 C430.2 57.28,45.93 v2(55.75,44.41) ; v2(50.29,48.09) R425.1
AD9508_VDD: length 6.7
  TOP w0.508: R38.2 v5(51.18,3.52) R36.2 50.43,3.15 48.9,3.15 48.77,3.27 R39.2 ; R313.1 v5(43.94,3.01) ; 42.16,5.93 v5(42.16,4.02)
  vias: v5(44.45,10.88) v5(49.53,12.28) v5(49.91,10.76)
ADCLK914OUT: length 3.6
  TOP w0.305: C39.1 14.41,23.33 R625.1 14.41,20.44 14.48,20.37 U16.11
ADCLK914VCC: length 5.6
  TOP w0.254: U16.13 v2(12.58,19.13) ; R625.2 v2(15.05,21.99) ; C654.1 17.06,18.95 v2(16.88,19.13) U16.8
  TOP w0.305: v2(12.58,19.13) 12.57,19.14 C655.1
  BOTTOM w0.254: 11.43,7.32 v2(11.23,7.32)
  BOTTOM w0.508: 11.43,7.32 12.51,8.41 12.51,8.47 E68.2
ADF4355_VDD_3V3: length 16.5
  TOP w0.254: v2(27.79,11.11) 27.72,11.11 27.64,11.19 27,11.19 U15.27 ; C669.2 11.85,13.21 ; 11.85,13.21 v5(12.19,13.55) ; 11.85,13.21 12.15,13.21 12.82,12.54 U18.2 ; v5(21.72,9.74) 22.06,10.08 U15.16
  TOP w0.305: v2(24,16.09) 24,15.27 24.17,15.1 24.17,15.04 24.26,14.94 U15.5 ; R611.2 v5(21.21,17.97)
  TOP w0.508: R619.2 31.37,9.87 v5(31.5,9.99)
  L10_SIGNAL w0.635: JP1.2 44.87,16.26 ; JP1.2 43.26,16.26 ; JP1.2 44.87,14.65 ; JP1.2 43.26,14.65
  BOTTOM w0.254: v2(27.79,11.11) 27.71,11.11 27.56,11.26 26.96,11.26 26.61,10.91 C616.1 C614.1
  vias: v5(12.19,12.91)
ADF4355_VRF_3V3: length 1.1
  TOP w0.305: 21.48,13.15 21.21,13.42 v5(21.21,14.12)
  vias: v5(16.26,11.01) v5(16.26,9.99)
ADF4355_VVCO_5V: length 10.2
  TOP w0.254: U15.19 23.76,8.74 23.37,8.34 C643.1 ; C618.1 23.05,16.03 23.5,15.58 23.5,15.2 23.76,14.93 U15.6
  TOP w0.305: C668.2 38.36,5.51 U17.2 ; U15.17 22.76,9.13 v5(22.1,8.47) C636.1 ; v5(21.15,16.03) C619.1 C618.1
  TOP w0.508: v5(39.37,5.29) 39.34,5.29 39.28,5.23 38.7,5.23 38.64,5.29 38.57,5.29 C668.2
  vias: v5(38.99,5.93)
ADF4355OUTA: length 1.6
  TOP w0.305: C632.2 14.48,15.64 U16.2
ADF4355OUTAB: length 1.6
  TOP w0.305: U16.1 13.98,15.66 C633.2
ADF4355OUTB: length 2.3
  TOP w0.305: U9.7 25.91,3.77 25.15,4.53 C638.2
ADF4355OUTBB: length 2.3
  TOP w0.305: C639.2 25.15,5.42 26.04,6.31 U9.5
ADP5054_1V2: length 7.6
  TOP w0.254: v1(30.23,40.89) v1(30.23,40.09) v1(30.23,39.29) v1(30.23,38.49) ; v1(28.63,39.29) U1.E5 ; U1.E9 v1(28.63,40.89)
  TOP w0.508: C525.1 48.9,43.01 48.44,43.47 v5(48.07,43.47)
  BOTTOM w0.254: v1(30.23,40.09) 30.23,39.9 C3.1 30.29,39.36 v1(30.23,39.29) 29.95,39.01 C2.1 ; C538.1 28.63,41.37 v1(28.63,40.89) ; v1(30.23,41.69) 30.23,41.55 C544.1
  vias: v5(53.87,37.55) v5(54.54,37.67) v5(54.66,36.87)
ADP5054_1V5: length 2.7
  BOTTOM w0.508: v5(40.94,45.43) 40.64,45.12 E1.2
  vias: v5(22.61,60.92) v5(23.62,60.92) v5(24.13,60.16) v5(24.64,60.92) v5(31.88,60.79) v5(32.51,59.9) v5(33.02,60.79) v5(33.66,59.9)
ADP5054_3V8: length 12.8
  TOP w0.508: 15.37,4.09 v5(16.19,4.09)
  L3_SIGNAL w0.508: v3(15.11,60.54) 13.46,60.54 12.83,59.9 v5(5.59,59.9)
  L11_GROUND w0.508: v4(15.11,61.3) v3(15.11,60.54)
  BOTTOM w0.508: R63.2 v4(15.11,61.3) ; 56.52,18.91 v5(56.52,18.25)
  vias: v5(5.59,60.67) v5(6.35,60.67) v5(9.02,15.45) v5(16.13,4.66) v5(39.24,63.08) v5(42.04,63.59) v5(55.44,18.63) v5(56.64,17.36)
ADP5054_5V5: length 0.8
  TOP w0.508: 39.56,12.28 v5(40.26,12.28)
  BOTTOM w0.508: E31.1 v5(32.26,13.68)
  vias: v5(32.51,23.71) v5(33.27,23.58) v5(40.26,12.91)
ADP5073_2V2: length 21
  BOTTOM w0.508: R443.1 24.38,62.57 25.4,61.56 25.4,60.16 29.59,55.97 32.77,55.97 35.05,53.68 35.05,52.92 36.45,51.52
CLK_N: length 3.5
  TOP w0.254: U1.C1 27.03,34.92 arc(27.1,34.56) 27.3,34.25
  TOP w0.686: C349.2 27.81,33.02 arc(27.68,33.69) 27.3,34.25
CLK_P: length 3.5
  TOP w0.254: 25.8,34.27 arc(26.12,34.74) U1.B1
  TOP w0.686: C348.2 25.27,32.99 arc(25.41,33.69) 25.8,34.27
CPOUT: length 8.6
  TOP w0.203: v2(22.09,14.95) 22.34,15.2 22.86,15.2 23.24,14.82 23.24,14.37 U15.7
  BOTTOM w0.203: R62.1 18.54,12.15 C62.1 C61.2 20.19,12.15 arc(20.66,12.25) 21.06,12.51 21.72,13.17 arc(22,13.59) 22.09,14.07 v2(22.09,14.95)
CS1: length 68
  TOP w0.203: U20.20 v2(52.86,56.25) ; U21.14 57.29,45.31 56.29,44.31 56.29,44.06 v2(56.11,43.88)
  L3_SIGNAL w0.203: v2(56.11,43.88) 56.11,43.92 56.13,43.95 56.13,44.04 56.29,44.19 56.29,44.31 58.29,46.32 58.29,52.67 55.24,55.71 53.4,55.71 v2(52.86,56.25) 52.86,57.46 51.94,58.38 47.89,58.38 47.22,57.71 47.22,56.2 46.42,55.41 37.03,55.41 34.16,52.54 30.48,52.54 v2(28.7,50.76)
  L10_SIGNAL w0.203: v2(52.86,56.25) 52.86,57.97 50.93,59.9 50.93,62.25 50.61,62.57 49.07,62.57 48.06,63.59 44.45,63.59 42.93,65.11 P2.2
  BOTTOM w0.203: R19.1 v2(28.7,50.76)
CS2: length 79.5
  TOP w0.203: U22.11 63,43 62.48,43.52 61.47,43.52 61.15,43.84 v2(60.77,43.84) ; R316.1 52.5,7.25 v2(52.58,7.33) 52.58,5.73 52.45,5.6 52.45,5.29 R38.1 ; U20.10 v2(47.36,60.94)
  L10_SIGNAL w0.203: v2(60.77,43.84) 61.85,44.92 61.85,48.86 59.05,51.65 59.05,53.17 57.02,55.21 51.69,55.21 49.4,57.49 49.4,58.25 48.39,59.27 48.39,60.54 47.99,60.94 v2(47.36,60.94)
  BOTTOM w0.203: 60.33,42.26 60.77,42.7 v2(60.77,43.84)
  BOTTOM w0.254: 60.33,42.26 60.33,39.58 60.96,38.95 60.96,30.95 60.33,30.31 60.33,13.04 57.66,10.37 54.36,10.37 52.58,8.6 v2(52.58,7.33)
CS3: length 89.6
  TOP w0.203: v2(63.75,41.87) 63.88,42 64.64,42 64.65,42 U22.13 ; v2(51.56,64.22) U20.4 ; R615.1 v2(25.02,16.98)
  L3_SIGNAL w0.203: v2(51.56,64.22) 52.07,63.71 52.07,63.33 54.99,60.41 54.99,59.59 63.06,51.52 63.06,42.56 v2(63.75,41.87)
  L10_SIGNAL w0.203: v2(25.02,16.98) 25.02,18.91 27.66,21.55 34.75,21.55 35.47,22.28 46.05,22.28 46.74,21.59 56.83,21.59 63.12,27.87 63.12,33.36 64.39,34.63 64.39,41.24 v2(63.75,41.87)
DAC_CSB: length 4.9
  BOTTOM w0.203: R19.2 29.03,48.4 29.03,44.49 v1(29.43,44.09)
DAC_SCLK: length 6.7
  BOTTOM w0.203: R23.2 31.24,48.3 30.63,47.69 30.63,42.89 v1(31.03,42.49)
DAC_SDIO: length 7.2
  L10_SIGNAL w0.203: v2(32.51,47.76) 32.51,46.39 30.61,44.49 30.61,42.87 v1(30.23,42.49)
  BOTTOM w0.203: R22.2 v2(32.51,47.76)
DAC_SDO: length 5.7
  BOTTOM w0.203: R20.2 29.82,48.58 29.82,43.7 v1(30.23,43.29)
DAC_TXEN_0: length 9.3
  TOP w0.203: R8.2 v2(32.13,31.94)
  L10_SIGNAL w0.203: v2(32.13,31.94) 31.29,31.94 29.03,34.2 29.03,36.31 29.24,36.51 29.84,36.51 v1(30.23,36.89)
DIV2IN: length 1.4
  TOP w0.203: U7.21 46.87,6.48 46.74,6.35 C341.2
DIV2INB: length 1.4
  TOP w0.203: C340.2 47.5,6.31 47.37,6.44 U7.22
DL1: length 2.9
  BOTTOM w0.203: Q1.2 46.23,35.39 46.73,34.89 U10.31
DL2: length 5.7
  L10_SIGNAL w0.203: v2(45.97,34) 46.23,34.25 v2(46.23,38.19)
  BOTTOM w0.203: Q1.5 v2(46.23,38.19) ; v2(45.97,34) 45.73,33.75 U10.29
EN: length 32.1
  TOP w0.203: U4.3 35.37,65.55 35.94,66.13 v2(35.94,66.76) ; R51.1 11.56,62.62 Q3.3 10.96,63.94 Q3.PAD2 v6(11.4,64.12)
  L2_GROUND w0.203: v6(11.4,64.12) v3(11.94,63.59)
  L3_SIGNAL w0.203: v2(35.94,66.76) 32.13,66.76 28.3,62.93 20.5,62.93 20.28,62.7 16.89,62.7 15.75,63.84 14.1,63.84 13.59,63.33 12.19,63.33 v3(11.94,63.59)
FMC_CS1: length 5.6
  TOP w0.203: U21.3 61.73,45.31 62.36,45.93 v2(65.02,45.93)
  BOTTOM w0.203: P1.H11 65,45.93 v2(65.02,45.93)
FMC_CS2: length 4.8
  TOP w0.203: U22.6 68.31,43 68.57,43.25 68.57,43.66 68.34,43.89 68.33,43.89 68.19,44.04 68.19,45.17 v2(68.88,45.86)
  BOTTOM w0.203: P1.D11 v2(68.88,45.86)
FMC_CS3: length 2
  TOP w0.203: U22.4 68.83,42 v2(68.88,42.05)
  BOTTOM w0.203: P1.D14 v2(68.88,42.05)
FMC_HMC849VCTL: length 2.3
  TOP w0.203: v2(68.88,40.78) 68.57,41.1 68.57,41.16 68.23,41.5 U22.3
  BOTTOM w0.203: P1.D15 v2(68.88,40.78)
FMC_MISO: length 4.6
  TOP w0.203: v2(63.8,47.13) 62.03,47.13 61.21,46.31 U21.5
  BOTTOM w0.203: P1.H10 v2(63.8,47.13)
FMC_MOSI: length 6
  TOP w0.203: U21.4 61.35,45.81 62.13,46.6 64.19,46.6 64.21,46.62 64.55,46.62 v2(65.07,47.13)
  BOTTOM w0.203: P1.G10 v2(65.07,47.13)
FMC_SCK: length 6.1
  TOP w0.203: v2(65.07,48.4) 64.33,47.67 61.93,47.67 61.08,46.81 U21.6
  BOTTOM w0.254: P1.G9 v2(65.07,48.4)
FMC_SCL: length 36.3
  TOP w0.203: U23.6 71.81,54.51 73.79,52.54 73.79,24.09 73.28,23.58 72,23.58 v2(71.42,23)
  BOTTOM w0.203: P1.C30 v2(71.42,23)
FMC_SDA: length 37.6
  TOP w0.203: U23.5 71.16,54.28 73.28,52.16 73.28,25.36 72.77,24.85 72,24.85 v2(70.15,23)
  BOTTOM w0.203: P1.C31 70.15,21.73 v2(70.15,23)
FMC_SPI_EN: length 51.8
  TOP w0.203: U20.6 v2(50.26,64.19) ; v2(66.3,44.66) 66.17,44.66 65.6,45.23 65.6,48.62 65.24,48.98 64.26,48.98 63.5,49.74 59.31,49.74 R73.2 58.93,49.36 U21.9
  TOP w0.254: 63.5,45.05 63.88,45.05 64.13,45.3 65.53,45.3 65.6,45.23 ; U22.9 v2(66.3,44.66)
  L3_SIGNAL w0.203: v2(68.88,44.59) 68.17,45.3 66.94,45.3 v2(66.3,44.66)
  L10_SIGNAL w0.203: v2(50.26,64.19) 51.31,65.24 53.59,65.24 55.83,63 56.11,63 56.76,62.36 56.76,61.39 61.26,56.88 61.26,53.38 63.12,51.52 63.12,46.06 63.88,45.3 65.66,45.3 v2(66.3,44.66)
  BOTTOM w0.203: P1.D12 v2(68.88,44.59)
FMC_TXEN_0: length 8.8
  TOP w0.203: U22.5 68.45,42.5 69.22,43.27 v2(70.23,43.27)
  BOTTOM w0.203: v2(70.23,43.27) 69.78,43.27 69.76,43.29 69.27,43.29 69.25,43.27 68.51,43.27 68.49,43.29 65.11,43.29 P1.H13
FMCA_VCC_12P0V: length 19.2
  TOP w0.508: v5(56.39,9.1) D1.C v5(57.67,7.7) ; C548.P 59.82,7.2 TP41.1
  TOP w0.635: 58.97,8.63 TP41.1 ; TP41.1 60.67,10.34 ; TP41.1 58.97,10.34
  L5_POWER w0.635: 59.01,10.29 TP41.1 ; TP41.1 60.62,8.68 ; TP41.1 60.62,10.29 ; TP41.1 59.01,8.68
  BOTTOM w0.508: P1.C35 70.8,16.02 v2(71.5,16.72) ; v2(70.12,14.3) 70.78,13.63 P1.C37 ; FL1.1 v5(54.24,3.28) ; v5(56.26,5.17) 56.26,3.39
  vias: v5(54.48,1.74) v5(54.61,4.79) v5(55.5,1.61)
GA0: length 49.9
  TOP w0.203: U23.1 73.11,58.42 74.8,56.73 74.8,54.95 74.3,54.44 74.3,18.5 73.15,17.36 70.85,17.36 v2(70.15,16.65)
  BOTTOM w0.254: P1.C34 v2(70.15,16.65)
GA1: length 56.4
  TOP w0.203: v2(72.39,63.08) 72.46,63.01 U23.2
  L10_SIGNAL w0.203: v2(68.88,15.38) 69.6,16.1 69.6,17.16 69.8,17.36 73.79,17.36 75.46,19.04 75.46,53.03 72.39,56.1 v2(72.39,63.08)
  BOTTOM w0.254: P1.D35 v2(68.88,15.38)
GBTCLK0_M2C_N: length 72.7
  TOP w0.127: C333.2 51.65,8.47 51.84,8.66 53.38,8.66 54.68,9.96 54.68,11.29 54.48,11.5 54.48,11.59 54.28,11.79 53.92,11.79 v1(53.7,12.01)
  L3_SIGNAL w0.127: v2(68.88,53.48) 69.4,54 69.53,54.02 69.53,54.02 69.65,54.03 71.66,54.03 73.66,52.03 73.66,14.31 72.64,13.3 72.64,12.28 72.14,11.77 53.94,11.77 v1(53.7,12.01)
  BOTTOM w0.203: P1.D5 v2(68.88,53.48)
GBTCLK0_M2C_P: length 72.7
  TOP w0.127: C334.2 51.65,9.1 51.84,8.91 53.28,8.91 54.43,10.07 54.43,11.19 54.23,11.39 54.23,11.49 54.18,11.54 53.93,11.54 v1(53.7,11.31)
  L3_SIGNAL w0.127: v1(53.7,11.31) 53.91,11.52 72.24,11.52 72.9,12.17 72.9,13.19 73.91,14.21 73.91,52.14 71.77,54.28 69.64,54.28 69.5,54.27 69.37,54.26 v2(68.88,54.75)
  BOTTOM w0.203: P1.D4 v2(68.88,54.75)
HMC365_VDD: length 0.8
  BOTTOM w0.254: 30.1,6.56 30.09,6.57 U6.2
  vias: v2(32,7.45)
HMC365OUT: length 21.2
  TOP w0.127: C341.1 46.74,5.08 46.99,4.82 46.99,3.9 46.48,3.39 R37.2 46.61,2.63 arc(46.88,2.52) 46.99,2.25 46.99,1.99 arc(46.96,1.85) 46.88,1.74 46.68,1.54 arc(46.62,1.5) 46.56,1.48 35.81,1.48 arc(35.28,1.71) 35.05,2.25 35.05,3.3 arc(34.88,3.72) 34.45,3.9 arc(34.19,3.95) 33.96,4.1 33.27,4.79 arc(32.99,4.97) 32.66,5.04 U9.3
HMC365OUTB: length 21.6
  TOP w0.127: C340.1 47.5,5.08 47.24,4.82 47.24,3.9 47.75,3.39 47.75,2.63 47.62,2.63 arc(47.36,2.52) 47.24,2.25 47.24,1.99 arc(47.2,1.76) 47.06,1.56 46.86,1.36 arc(46.72,1.26) 46.56,1.23 35.81,1.23 arc(35.1,1.53) 34.8,2.25 34.8,3.3 arc(34.7,3.54) 34.45,3.64 arc(34.19,3.59) 33.96,3.44 33.55,3.03 arc(32.96,2.64) 32.27,2.5 U9.1
HMC849_VDD: length 2
  BOTTOM w0.203: E66.2 12.51,10.63
  BOTTOM w0.508: v2(11.94,12.15) 12.51,11.58 12.51,10.63
  vias: v2(19.69,22.95)
HMC849VCTL: length 87.9
  TOP w0.203: v2(63.75,40.85) 64.4,41.5 U22.14 ; R31.2 v2(22.23,24.22) ; U20.9 v2(47.65,61.59)
  L3_SIGNAL w0.203: v2(47.65,61.59) 48.13,61.59 49.15,60.57 49.15,59.78 49.66,59.27 52.58,59.27 61.85,50 61.85,42.76 v2(63.75,40.85)
  L10_SIGNAL w0.203: v2(22.23,24.22) 30.96,24.22 31.42,24.67 38.1,24.67 39.12,23.66 56.62,23.66 62.36,29.4 62.36,33.36 63.75,34.76 v2(63.75,40.85)
IRQB: length 11.1
  TOP w0.203: CR5.C 32.56,28.84 32.03,29.37 31.55,29.37 TP21.1
  BOTTOM w0.203: v1(30.23,37.69) 30.63,37.29 30.63,30.85 TP21.1
LTC2928_ON: length 63.7
  L8_POWER w0.203: v2(12.45,34.78) 12.34,34.68 9.09,34.68 8.38,35.39 8.38,41.31 7.78,41.91 7.78,52.75 5.28,55.26 2.59,55.26 v2(2.54,55.21)
  L11_GROUND w0.203: v4(41.53,28.93) 40.4,28.93 39.55,28.08 34.77,28.08 28.07,34.78 v2(12.45,34.78)
  BOTTOM w0.203: U10.17 v4(41.53,28.93) 40.88,28.93 R416.1 ; R70.2 v2(2.54,55.21)
LTC2928_ON_A: length 67.6
  L10_SIGNAL w0.203: v2(51.05,46.7) 45.59,46.7 42.29,50 42.29,55.59 41.15,56.73 38.48,56.73 35.81,54.06 35.81,51.27 34.04,49.49 32.77,49.49 31.88,50.38 31.88,51.4 30.1,53.17 28.57,53.17 26.04,55.71 17.14,55.71 16.64,55.21 14.52,55.21 12.83,53.51 11.98,53.51 11.05,54.44 5.97,54.44 4.06,56.35 v2(2.54,56.35)
  BOTTOM w0.203: U11.3 51.19,46.57 v2(51.05,46.7) ; R71.2 v2(2.54,56.35)
MISO: length 45.5
  TOP w0.203: U20.19 v2(52.21,56.49) ; v2(56.13,45.68) 56.76,46.31 U21.12
  L3_SIGNAL w0.203: v2(56.13,45.68) 57.66,47.2 57.66,52.54 55.24,54.95 53.09,54.95 52.21,55.83 v2(52.21,56.49) 52.21,57.35 51.69,57.87 50.19,57.87 49.3,56.98 48.51,56.98 47.88,56.35 47.88,55.84 46.86,54.82 43.05,54.82 41.53,53.3 39.62,53.3 39.12,53.81 36.32,53.81 34.54,52.03 31.24,52.03 v2(29.97,50.76)
  BOTTOM w0.203: R20.1 v2(29.97,50.76)
MOSI: length 140.8
  TOP w0.203: R36.1 50.93,4.91 50.93,5.29 51.5,5.87 R315.1 ; U20.18 v2(51.56,56.6) ; U21.13 57.15,45.81 56.45,45.1 v2(55.69,45.1) ; R614.1 v2(26.54,16.41)
  TOP w0.254: v2(51.94,6.06) R315.1
  L3_SIGNAL w0.203: v2(55.69,45.1) 55.37,45.43 ; 55.37,45.43 54.28,45.43 53.47,44.61 53.47,38.82 53.09,38.44 53.09,35.77 55.08,33.78 55.08,27.61 54.1,26.63 54.1,20.28 50.67,16.85 50.67,7.58 50.61,7.52 51.94,6.18 v2(51.94,6.06) 51.94,5.72 50.03,3.81 49.82,3.81 48.98,2.97 48.9,2.97 47.27,1.33 47.24,1.36 34.92,1.36 29.34,6.95 29.34,8.34 26.42,11.26 26.42,16.28 v2(26.54,16.41) ; 55.37,45.43 55.37,45.93 55.72,46.28 55.97,46.28 57.02,47.33 57.02,52.28 55.12,54.19 52.83,54.19 51.56,55.46 v2(51.56,56.6)
  L10_SIGNAL w0.203: v2(51.56,56.6) 51.56,57.62 49.02,60.16 49.02,61.81 47.74,63.09 43.68,63.09 P2.1 38.48,64.48 38.48,61.94 37.08,60.54 36.32,60.54 34.54,58.76 34.54,57.49 33.91,56.86 33.91,52.16 v2(32.51,50.76)
  BOTTOM w0.203: R22.1 v2(32.51,50.76)
PG_C2M: length 82.1
  L3_SIGNAL w0.203: v2(53.09,48.98) 53.09,48.98 53.09,48.09 52.32,47.33 52.32,39.97 51.82,39.46 v2(51.82,32.35) 52.2,31.96 v2(52.2,24.97) ; v2(55.96,62.22) 56.6,61.57 57.52,61.57 59.56,59.52 67.92,59.52 v2(68.88,58.56) ; v2(39.62,27.27) 40.51,28.15 40.51,32.12 39.29,33.34 v2(39.29,33.41)
  L10_SIGNAL w0.203: v2(52.2,24.97) 52.18,24.98 49.91,24.98 47.62,27.27 v2(39.62,27.27) ; v2(54.36,56.35) 54.36,60.62 v2(55.96,62.22)
  BOTTOM w0.203: 52.7,49.87 53.09,49.49 v2(53.09,48.98) U11.6 ; 52.7,49.87 53.47,50.63 53.47,55.46 v2(54.36,56.35) ; 52.7,49.87 51.69,49.87 R436.1 ; v2(52.2,24.97) 51.96,24.73 R411.2 ; v2(51.82,32.35) 52.45,32.35 52.7,32.09 R47.2 ; R412.2 v2(39.62,27.27) ; P1.D1 v2(68.88,58.56) ; R410.2 39.65,32.98 39.29,33.34 v2(39.29,33.41)
PGC: length 10.8
  TOP w0.203: v2(56.9,59.64) U20.24
  BOTTOM w0.203: XP1.3 54.48,66.38 57.15,63.71 57.15,59.89 v2(56.9,59.64)
PWRGD: length 64.2
  TOP w0.203: v2(18.16,64.35) 18.36,64.55 DS1.C ; v2(55.24,64.73) 54.54,64.03 U20.28
  L10_SIGNAL w0.203: v2(55.24,64.73) 55.24,67.02 54.48,67.78 39.24,67.78 37.47,66 32.44,66 30.15,63.71 27.43,63.71 26.8,64.35 v2(18.16,64.35) 14.61,64.35 13.59,63.33 12.37,63.33 12.14,63.1 11.74,63.1 11.51,63.33 6.35,63.33 4.7,61.68 v2(4.7,59.78)
  BOTTOM w0.203: v2(4.7,59.78) 5.08,59.4 5.21,59.4 5.48,59.12 U8.19
REF: length 2.1
  BOTTOM w0.203: R75.2 11.05,54.06 10.61,54.51 U8.5
REF_4355_N: length 13.5
  TOP w0.203: Y61.5 40.13,16.47 37.59,13.93 35.43,13.93 33.27,11.77 32.26,11.77 31.62,11.14 C610.1
REF_4355_P: length 9.8
  TOP w0.203: Y61.4 37.59,15.58 36.83,14.82 R65.1 34.67,14.57 33.66,13.55 33.15,13.55 32.26,12.66
SA_GND: length 7.8
  TOP w0.254: C32.7 6.63,31.96 6.58,31.91 6.43,31.91 v2(6.35,31.84) ; C32.1 8.76,31.46 v2(9.14,31.08) ; v2(6.48,33.23) 6.73,32.98 C32.5 ; C33.5 8.76,45.68 v5(9.14,45.3) ; C33.7 9.27,46.7 v5(9.53,46.95) ; v5(6.48,47.71) 6.99,47.2 C33.1 ; 9.65,32.47 C32.3 ; C33.3 6.48,46.19 v5(6.22,45.93)
  vias: v5(1.07,36.75) v5(1.07,35.84) v5(1.07,34.31) v5(1.14,44.41) v5(1.14,42.89) v5(2.06,36.8) v5(2.21,35.84) v5(2.21,34.31) v5(2.29,44.41) v5(2.29,42.89) v5(3.35,34.31) v5(3.43,44.41) v5(4.62,34.31) v5(4.7,44.41) v7(0.91,39.15) v7(0.97,41.49) v7(2.18,39.15) v7(2.24,41.49) v7(3.51,41.49) v7(3.45,39.15) v7(4.78,41.49) v7(4.72,39.15)
SCK: length 153.5
  TOP w0.203: R314.1 44.26,4.79 R35.1 43.05,4.41 v2(43.05,3.9) ; R613.1 v2(27.18,16.98) ; P2.3 44.83,65.75 44.83,64.98 41.66,61.81 41.66,56.6 42.54,55.71 46.45,55.71 46.58,55.84 48.26,55.84 v2(48.77,56.35) 49.02,56.6 49.27,56.6 49.61,56.94 U20.15 ; v2(55.75,46.81) U21.11
  L3_SIGNAL w0.203: v2(43.05,3.9) 48.26,9.1 48.26,14.44 49.02,15.2 49.02,18.07 53.21,22.26 53.21,34.76 52.58,35.39 52.58,38.82 52.88,39.13 52.88,44.79 54.9,46.81 v2(55.75,46.81) ; v2(31.24,50.76) 31.88,51.4 34.92,51.4 36.83,53.3 38.86,53.3 39.52,52.64 42.01,52.64 43.69,54.32 47.62,54.32 48.77,55.47 v2(48.77,56.35)
  L10_SIGNAL w0.203: v2(43.05,3.9) 47.5,8.34 47.5,15.58 48.26,16.34 48.26,18.76 47.5,19.52 30.56,19.52 28.02,16.98 v2(27.18,16.98) ; v2(48.77,56.35) 48.77,55.83 50.16,54.44 56.13,54.44 57.53,53.05 57.53,48.09 56.64,47.2 56.15,47.2 v2(55.75,46.81)
  BOTTOM w0.203: R23.1 v2(31.24,50.76)
SERDIN0_N: length 13.1
  TOP w0.203: C816.1 39.09,49.74 39,49.83 33.11,49.83 31.42,48.14 31.42,44.49 U1.H12
SERDIN0_P: length 12.9
  TOP w0.203: U1.H13 30.96,44.96 30.96,48.33 32.92,50.29 39,50.29 39.09,50.38 C815.1
SERDIN1_N: length 9.4
  TOP w0.203: U1.K12 33.02,44.49 33.02,45.17 33.83,45.98 33.83,46.96 34.67,47.8 38.87,47.8 38.96,47.71 C82.1
SERDIN1_P: length 9.2
  TOP w0.203: U1.K13 32.56,44.96 32.56,45.36 33.38,46.17 33.38,47.15 34.48,48.26 38.87,48.26 38.96,48.35 C81.1
SERDIN2_N: length 4.7
  TOP w0.203: U1.N11 35.13,43.18 35.4,43.18 35.49,43.27 35.65,43.43 35.69,43.47 35.95,43.74 38.87,43.74 38.96,43.65 C84.1
SERDIN2_P: length 5.6
  TOP w0.203: C83.1 38.96,44.28 38.87,44.19 35.76,44.19 35.33,43.76 35.29,43.72 35.25,43.72 35.19,43.72 35.18,43.71 34.87,43.71 34.86,43.72 34.81,43.72 34.38,43.29 U1.M11
SERDIN3_N: length 4.6
  TOP w0.203: U1.N9 35.05,41.67 35.85,41.67 36.27,42.09 38.87,42.09 38.96,42 C86.1
SERDIN3_P: length 5.6
  TOP w0.203: C85.1 38.96,42.63 38.87,42.54 36.08,42.54 35.66,42.12 34.66,42.12 U1.M9
SERDIN4_N: length 4.5
  TOP w0.203: C811.1 38.96,38.7 38.87,38.61 35.14,38.61 U1.N5
SERDIN4_P: length 5.4
  TOP w0.203: C812.1 38.96,38.06 38.87,38.15 35.34,38.15 35.28,38.09 34.63,38.09 U1.M5
SERDIN5_N: length 2.8
  TOP w0.203: U1.N3 35.22,37.08 37.2,37.08 37.29,37.17 C87.1
SERDIN5_P: length 3.8
  TOP w0.203: C88.1 37.29,36.54 37.2,36.63 35.51,36.63 35.37,36.49 34.63,36.49 U1.M3
SERDIN6_N: length 9.1
  TOP w0.203: U1.K2 33.04,35.68 33.04,34.96 33.58,34.43 36.51,34.43 38.77,32.17 39.19,32.17 39.27,32.09 39.41,32.09 C813.1
SERDIN6_P: length 8.9
  TOP w0.203: U1.K1 32.59,35.25 32.59,34.77 33.39,33.97 36.32,33.97 38.49,31.8 38.44,31.8 38.52,31.71 39,31.71 39.08,31.63 C814.1
SERDIN7_N: length 11.5
  TOP w0.203: C89.1 39.1,30.47 39,30.36 37.36,30.36 37.16,30.57 35.55,30.57 34.43,31.69 31.42,34.69 31.42,35.7 U1.H2
SERDIN7_P: length 11.4
  TOP w0.203: U1.H1 30.96,35.23 30.96,34.5 34.24,31.23 34.24,31.23 35.36,30.11 36.97,30.11 37.17,29.91 39,29.91 39.1,29.81 C810.1
SLEW: length 1.5
  BOTTOM w0.203: R425.2 50.9,46.06 50.91,46.07 U11.2
SPI33: length 4.3
  TOP w0.508: R6.1 R5.1 v5(32.64,27.98)
  L3_SIGNAL w0.203: 30.02,42.07 30.53,42.07 ; 30.61,42.25 30.61,43.52 30.45,43.67 30,43.67
  vias: v1(31.03,41.69) v1(31.03,38.49) v5(26.29,62.32) v5(26.29,61.43)
SUPPLY33: length 23.6
  TOP w0.203: U21.16 58.93,44.16 58.67,43.9 58.42,43.9
  TOP w0.254: U22.16 v2(66.3,39.72) ; v2(49.68,56.2) 50.27,56.2 50.91,56.84 U20.17
  TOP w0.305: U20.11 v2(47.75,60.29)
  TOP w0.508: C76.1 v2(57.66,43.9) 58.42,43.9 ; v5(60.13,61.87) XR2.1 ; E32.2 v5(47.37,17.21) v5(47.37,17.84) v5(47.37,18.48) ; C77.1 v2(66.3,39.72) ; 61.72,63.33 62.1,63.33 62.99,64.22 v2(63.12,64.22)
  L8_POWER w0.635: XP1.2 52.29,67.23 ; XP1.2 50.58,67.23 ; XP1.2 52.29,65.53 ; XP1.2 50.58,65.53
  L11_GROUND w0.508: v4(17.14,57.24) v3(17.65,57.75)
  BOTTOM w0.508: XC6.1 v2(48.77,57.75) ; XC5.1 54.99,57.87 v2(55.24,57.62) ; XC4.P v2(63.12,64.22) ; R28.2 v5(46.33,64.3) ; R66.1 v4(17.14,57.24)
  vias: v2(30.35,62.95) v2(31.37,63.71) v2(31.37,62.95) v2(31.62,61.94) v2(32.51,61.94)
SVPLL12_EN: length 2
  TOP w0.203: U3.16 33.26,57.73 33.65,58.12 v2(33.66,58.12)
  BOTTOM w0.203: R338.2 32.89,58.89 v2(33.66,58.12)
SVSYN33_EN: length 1.6
  BOTTOM w0.203: U14.7 37.71,65.49 R339.2
SVSYNC33: length 2
  BOTTOM w0.305: C522.2 37.71,59.35 U14.2
  vias: v1(32.63,42.49) v1(32.63,37.69) v5(39.05,54.51) v5(40,54.51)
SW1: length 1
  BOTTOM w0.203: Q1.PAD1 46.88,36.98 Q1.6
SWITCH2BALUN: length 1
  TOP w0.381: R332.1 C38.1
SYNC_N: length 26
  TOP w0.127: JP34.1 SYNCN.1 51.94,49.74 51.31,50.38 48.61,50.38 v1(48.39,50.16)
  L3_SIGNAL w0.127: v1(31.83,41.69) 31.83,41.74 31.95,41.87 38.86,41.87 47.37,50.38 48.16,50.38 v1(48.39,50.16)
SYNC_P: length 26.5
  TOP w0.127: JP33.1 SYNCP.1 51.31,50.63 48.61,50.63 v1(48.39,50.86)
  L3_SIGNAL w0.127: v1(48.39,50.86) 48.2,50.67 47.3,50.67 38.76,42.12 31.95,42.12 31.83,42.25 v1(31.83,42.49)
  BOTTOM w0.203: R26.2 31.88,42.44 v1(31.83,42.49)
SYSREF2_N: length 44.2
  TOP w0.127: JP32.1 56.69,51.66 v1(56.27,51.66) ; v1(47.08,16.34) 46.86,16.12 46.86,14.25 C344.2
  L3_SIGNAL w0.127: v1(56.27,51.66) 56.03,51.9 53.7,51.9 51.94,50.15 51.94,48.62 50.04,46.72 50.04,23.1 46.81,19.87 46.81,16.98 46.86,16.92 46.86,16.57 v1(47.08,16.34)
SYSREF2_P: length 44.7
  TOP w0.127: C345.2 46.61,14.63 46.61,16.12 v1(46.39,16.34) ; JP31.1 56.71,52.28 v1(56.27,52.28)
  L3_SIGNAL w0.127: v1(56.27,52.28) 56.14,52.16 53.59,52.16 51.69,50.25 51.69,48.73 49.78,46.82 49.78,23.2 46.56,19.98 46.56,16.87 46.61,16.82 46.61,16.57 v1(46.39,16.34)
SYSREF_N: length 45.9
  TOP w0.127: C346.2 42.96,9.1 42.71,8.85 42.58,8.85 42.58,8.85 42.2,8.85 42.04,9.01 v1(42.04,9.08)
  L3_SIGNAL w0.127: v1(42.04,9.08) 41.86,8.9 41.52,8.9 41.02,9.4 41.02,10.12 42.04,11.14 42.04,13.55 42.93,14.44 42.93,24.09 43.48,24.65 43.48,32.67 42.48,33.68 40.12,33.68 39.98,33.82 39.98,33.89 40.11,34.02 40.49,34.02 v1(40.64,34.17)
  L10_SIGNAL w0.127: v1(40.64,34.17) 40.59,34.12 40.11,34.12 39.98,34.25 39.98,35.09 39.02,36.05 36.57,36.05 35.02,34.5 30.18,34.5 29.79,34.89 29.79,35.72 v1(29.43,36.09)
SYSREF_P: length 45.7
  TOP w0.127: v1(42.04,8.38) 42.04,8.43 42.2,8.6 42.71,8.6 42.99,8.32 C347.2
  L3_SIGNAL w0.127: v1(39.04,34.17) 39.19,34.02 39.6,34.02 39.73,33.89 39.73,33.71 40.01,33.42 42.37,33.42 43.23,32.57 43.23,24.75 42.67,24.2 42.67,14.54 41.78,13.65 41.78,11.26 40.77,10.25 40.77,9.3 41.47,8.6 41.76,8.6 41.97,8.38 v1(42.04,8.38)
  L10_SIGNAL w0.127: v1(39.04,34.17) 39.07,34.15 39.5,34.15 39.73,34.38 39.73,34.99 38.91,35.8 36.68,35.8 35.13,34.25 30.07,34.25 29.43,34.89 v1(29.43,35.29)
  BOTTOM w0.203: R32.2 29.43,35.42 v1(29.43,35.29)
TOAD9508: length 21.3
  TOP w0.203: R329.1 v2(45.09,2.37) ; v2(31.08,14.03) 30.94,14.03 30.73,14.23 R629.2
  L3_SIGNAL w0.203: v2(45.09,2.37) 44.83,2.37 44.7,2.25 41.53,2.25 34.12,9.65 34.12,10.37 30.99,13.51 30.99,13.94 v2(31.08,14.03)
TXEN_0: length 74.5
  TOP w0.203: U20.8 v2(47.54,62.24)
  TOP w0.254: v2(60.96,39.84) 62.61,39.84 62.99,40.22 62.99,41.9 63.59,42.5 U22.12
  L10_SIGNAL w0.203: v2(60.96,39.84) 60.96,38.19 59.82,37.04 58.17,37.04 56.64,35.52 50.16,35.52 47.6,32.95 41.35,32.95 40.89,32.5 35.46,32.5 v2(35.08,32.88) ; 60.71,42 62.48,43.78 62.48,49.24 59.82,51.9 59.82,55.08 57.18,57.72 v2(56.11,57.72)
  L10_SIGNAL w0.254: 60.71,42 60.33,41.62 60.33,40.47 v2(60.96,39.84)
  BOTTOM w0.203: v2(35.08,32.88) 34.98,32.98 34.59,32.98 33.4,31.79 R18.1 ; v2(47.54,62.24) 55.07,62.24 55.98,61.33 55.98,59.86 56.12,59.73 56.12,57.85 56.11,57.84 v2(56.11,57.72)
UNNAMED_2_AD916X_I16_ISET: length 3.3
  TOP w0.203: R7.1 22.44,44.5 25.02,44.5 U1.A12
UNNAMED_2_AD916X_I16_PLLLDOBYPA: length 4.2
  TOP w0.203: 38.1,40.98 37.21,40.98 36.72,40.49 34.7,40.49 34.31,40.1 U1.M7
UNNAMED_2_AD916X_I16_RESETB: length 10.8
  TOP w0.203: v2(30.58,28.51) 30.68,28.41 R4.1
  BOTTOM w0.203: v1(31.03,37.69) 31.03,31.57 31.57,31.02 31.57,29.5 v2(30.58,28.51)
UNNAMED_2_AD916X_I16_VBGNEG: length 3.9
  L5_POWER w0.127: 25.15,42.89 25.91,42.89
  L5_POWER w0.203: v1(27.03,41.69) 27.03,41.77 25.91,42.89 ; v2(24.13,42.89) 25.15,42.89
  BOTTOM w0.203: C8.1 v2(24.13,42.89)
UNNAMED_2_AD916X_I16_VREF: length 3.3
  TOP w0.203: U1.A13 24.77,45.55 C23.1
UNNAMED_2_CAP_I5_N1: length 1.1
  TOP w0.203: C21.1 R21.1
UNNAMED_2_CAP_I7_N1: length 3.6
  TOP w0.203: R3.1 R5.2 C7.1 R4.2
UNNAMED_2_DIOLED_I17_P: length 1.7
  TOP w0.203: CR5.A 34.96,27.18 R6.2
UNNAMED_3_AD9508_I1155_CSN: length 2
  TOP w0.203: R316.2 50.74,7.33 49.95,8.11 U7.1
UNNAMED_3_AD9508_I1155_EXTCAP0: length 2.2
  TOP w0.203: C325.2 50.97,10.63 50.45,10.11 U7.5
UNNAMED_3_AD9508_I1155_EXTCAP1: length 2.6
  TOP w0.203: U7.14 43.28,10.11 C326.1
UNNAMED_3_AD9508_I1155_INSEL: length 3.5
  TOP w0.203: U7.23 47.87,6.84 48.77,5.94 R39.1 R330.1
UNNAMED_3_AD9508_I1155_OUT0: length 1.7
  TOP w0.203: U7.2 50.22,8.61 50.36,8.47 C333.1
UNNAMED_3_AD9508_I1155_OUT0N: length 1.6
  TOP w0.203: C334.1 50.36,9.1 50.35,9.11 U7.3
UNNAMED_3_AD9508_I1155_OUT2: length 2.4
  TOP w0.203: U7.11 46.37,12.42 46.99,13.04 C344.1
UNNAMED_3_AD9508_I1155_OUT2N: length 2.2
  TOP w0.203: C345.1 46.1,12.91 45.85,12.66 45.85,11.38 U7.12
UNNAMED_3_AD9508_I1155_OUT3: length 1.5
  TOP w0.203: U7.16 43.63,9.11 C346.1
UNNAMED_3_AD9508_I1155_OUT3N: length 1.7
  TOP w0.203: U7.17 44.02,8.61 C347.1
UNNAMED_3_AD9508_I1155_RESETN: length 3.3
  TOP w0.203: U7.18 44.41,8.11 R311.2 43.43,7.01 R312.2
UNNAMED_3_AD9508_I1155_SCLK: length 2.2
  TOP w0.203: R314.2 44.58,6.07 U7.19
UNNAMED_3_AD9508_I1155_SDIO: length 3.3
  TOP w0.203: R315.2 49.28,6.06 48.37,6.97 U7.24
UNNAMED_3_AD9508_I1155_SYNCN: length 4.7
  TOP w0.203: 45.21,3.64 45.72,4.15 45.72,5.48 45.47,5.74 ; 45.47,5.74 46.37,6.64 U7.20 ; 45.47,5.74 R310.2
UNNAMED_3_ADHMC849_I1139_VCTL: length 1.5
  TOP w0.305: U5.2 19.84,24.65 arc(20.41,24.54) R31.1
UNNAMED_3_ADM7150_I1277_BYP: length 1.8
  BOTTOM w0.203: U6.3 29.6,6.31 C312.2
UNNAMED_3_ADM7150_I1277_REF: length 0.6
  BOTTOM w0.203: U6.6 29.6,10.37 29.21,10.76
UNNAMED_3_ADM7150_I1277_VREG: length 5
  L3_SIGNAL w0.203: v2(31.12,6.82) 33.15,6.82 v2(33.78,6.18)
  BOTTOM w0.203: v2(31.12,6.82) 30.6,7.34 U6.1 ; C310.2 33.44,6.18 v2(33.78,6.18)
UNNAMED_3_CAP_I1148_N2: length 1.5
  TOP w0.305: C39.2 14.37,24 U5.12
UNNAMED_3_CAP_I1149_N2: length 1.4
  TOP w0.305: C34.2 U5.9
UNNAMED_3_CAP_I1150_N2: length 1.5
  TOP w0.254: C38.2 19.55,25.36 U5.3
UNNAMED_3_CAP_I1305_N1: length 2.4
  TOP w0.686: C349.1 T33.6
UNNAMED_3_CAP_I1306_N1: length 2.4
  TOP w0.686: C348.1 T33.4
UNNAMED_3_CAP_I1318_N1: length 4.9
  TOP w0.508: C14.1 2.79,40.27 J32.1
UNNAMED_3_CAP_I1318_N2: length 8.9
  TOP w0.457: C14.2 T1.3
UNNAMED_3_CNBNC5P_I1037_CNTR: length 13.1
  TOP w0.203: C34.1 13.59,25.95
  TOP w0.686: 12.89,25.95 9.91,25.95 arc(9.4,25.85) 8.97,25.57 5.43,22.03 arc(5.18,21.86) 4.89,21.8 J31.1
UNNAMED_3_RES_I1265_N2: length 2.2
  TOP w0.254: T33.3 25.26,24.55 arc(24.36,25.15) R332.2
UNNAMED_4_ADP5054_I1011_BST1: length 1.6
  BOTTOM w0.203: U10.32 47.23,34.37 47.5,34.63
UNNAMED_4_ADP5054_I1011_BST2: length 1.5
  BOTTOM w0.203: U10.28 45.23,34.61 45.21,34.63
UNNAMED_4_ADP5054_I1011_BST3: length 1.6
  BOTTOM w0.203: C413.1 49.23,25.06 U10.1
UNNAMED_4_ADP5054_I1011_BST4: length 1.5
  BOTTOM w0.203: C415.1 43.73,24.94 U10.12
UNNAMED_4_ADP5054_I1011_CFG12: length 5.8
  BOTTOM w0.203: R41.2 38.14,30.19 38.82,30.87 40.08,30.87 R48.1 41.2,30.19 41.96,29.43 U10.18
UNNAMED_4_ADP5054_I1011_CFG34: length 2.9
  BOTTOM w0.203: R42.1 R49.1 41.99,26.58 42.09,26.58 42.44,26.93 U10.13
UNNAMED_4_ADP5054_I1011_COMP1: length 4.7
  BOTTOM w0.203: U10.40 50.72,30.93 50.87,30.77 53.47,30.77 53.77,31.08 R44.2
UNNAMED_4_ADP5054_I1011_COMP2: length 5.2
  BOTTOM w0.203: U10.20 42.43,30.43 41.87,30.99 41.87,30.99 41.16,31.71 39.2,31.71 R45.2
UNNAMED_4_ADP5054_I1011_COMP3: length 7.2
  L10_SIGNAL w0.203: v2(51.56,25.61) 52.04,25.61 52.16,25.5 52.42,25.5 52.43,25.49 53.85,25.49 54.23,25.11 v2(54.74,25.11)
  BOTTOM w0.203: U10.47 50.51,27.43 50.84,27.1 50.84,25.86 51.08,25.61 v2(51.56,25.61) ; R46.2 v2(54.74,25.11)
UNNAMED_4_ADP5054_I1011_COMP4: length 5.2
  BOTTOM w0.203: 37.85,27.77 37.96,27.9 42.95,27.9 U10.15
UNNAMED_4_ADP5054_I1011_EN1: length 1.5
  BOTTOM w0.203: U10.39 51.41,31.43 R47.1
UNNAMED_4_ADP5054_I1011_EN2: length 3
  BOTTOM w0.203: U10.21 42.48,30.93 41.53,31.88 R410.1
UNNAMED_4_ADP5054_I1011_EN3: length 2.2
  BOTTOM w0.203: U10.48 49.98,25.16 50.04,25.11 R411.1
UNNAMED_4_ADP5054_I1011_EN4: length 1.5
  BOTTOM w0.203: U10.14 41.69,27.43 R412.1
UNNAMED_4_ADP5054_I1011_FB1: length 18.3
  BOTTOM w0.203: R15.2 57.7,37.59 C11.1 56.9,37.59 56.77,37.46 R16.1 57.79,35.27 57.79,30.44 57.4,30.05 54.61,30.05 54.47,30.2 53.86,30.2 53.67,30.39 50.72,30.39 50.68,30.43 U10.41
UNNAMED_4_ADP5054_I1011_FB2: length 30.3
  L6_POWER w0.203: v2(35.94,46.09) 35.94,44.43 37.72,42.65 37.72,31.94 37.52,31.74 35.89,31.74 v2(35.79,31.84)
  BOTTOM w0.203: v2(35.94,46.09) R1.1 R2.1 35.94,42.29 C13.1 ; v2(35.79,31.84) 35.79,31.66 36.2,31.25 40.97,31.25 42.3,29.93 U10.19
UNNAMED_4_ADP5054_I1011_FB3: length 2.8
  BOTTOM w0.203: 51.56,26.5 51.56,27.65 51.31,27.89 50.43,27.89 50.4,27.93 U10.46
UNNAMED_4_ADP5054_I1011_FB4: length 8.7
  BOTTOM w0.203: U10.16 41.4,28.43 41.23,28.26 38.58,28.26 38.35,28.48 35.76,28.48 R423.1 R419.2
UNNAMED_4_ADP5054_I1011_RT: length 5.1
  BOTTOM w0.203: U10.42 50.05,30 50.48,30 50.49,30.01 53.4,30.01 53.72,29.69 53.84,29.69 54.23,29.3 R413.1
UNNAMED_4_ADP5054_I1011_SW31: length 1.8
  BOTTOM w0.203: U10.4 47.73,25.59 47.5,25.36 47.23,25.63 U10.5
UNNAMED_4_ADP5054_I1011_SW41: length 2
  BOTTOM w0.203: 45.21,25.23 45.23,25.25 45.23,25.36 ; 45.23,25.36 45.73,25.86 U10.8 ; 45.23,25.36 U10.9
UNNAMED_4_ADP5054_I1011_SYNC: length 1.7
  BOTTOM w0.203: U10.44 50.4,28.93 50.43,28.96 51.39,28.96 51.56,28.79
UNNAMED_4_ADP5054_I1011_VDD: length 5.5
  BOTTOM w0.203: U10.43 50.8,29.43 50.95,29.57 53.28,29.57 53.38,29.47 53.39,29.47 53.56,29.31 53.58,29.31 54.01,28.88 54.01,28.77 54.18,28.61 54.28,28.61 C411.2
UNNAMED_4_ADP5073_I1002_COMP: length 3.5
  BOTTOM w0.203: 55.37,49.87 54.23,49.87 53.62,49.27 53.62,48.63 53.59,48.6 U11.7
UNNAMED_4_ADP5073_I1002_FB: length 4.9
  BOTTOM w0.203: U11.8 54.09,48.21 54.61,48.73 R434.1 R430.2
UNNAMED_4_ADP7183_I808_VA: length 2.6
  BOTTOM w0.203: U12.3 19.94,55.97 C434.2 C435.1
UNNAMED_4_ADP7183_I808_VAFB: length 1.8
  BOTTOM w0.203: C434.1 19.44,56.74 U12.4
UNNAMED_4_ADP7183_I808_VREG: length 1.9
  BOTTOM w0.203: U12.7 20.44,60.92 C427.2
UNNAMED_4_CAP_I904_N2: length 21.5
  L10_SIGNAL w0.203: v2(60.07,48.6) 59.18,48.6 56.86,46.28 55.03,46.28 53.85,47.46 52.83,47.46 51.02,49.27 49.41,49.27 48.74,48.6 45.34,48.6 44.96,48.98 v2(44.32,48.98)
  BOTTOM w0.203: v2(44.32,48.98) 44.26,48.92 D42.A ; R430.1 59.05,48.09 59.56,48.09 v2(60.07,48.6)
UNNAMED_4_CAP_I949_N2: length 5.6
  BOTTOM w0.203: 37.59,23.46 37.21,23.84 35.81,23.84 34.54,25.11 34.54,27.01
UNNAMED_4_CAP_I1000_N1: length 5.2
  BOTTOM w0.203: R437.2 54.23,51.4 55.63,52.79 56.77,52.79 57.15,52.41 57.15,51.14
UNNAMED_4_CAP_I1019_N2: length 1.7
  BOTTOM w0.203: R44.1 56.22,32.64 C47.2
UNNAMED_4_CAP_I1026_N2: length 1.7
  BOTTOM w0.203: R45.1 36.7,32.51 C48.2
UNNAMED_4_CAP_I1027_N2: length 1.3
  BOTTOM w0.203: R46.1 C49.2
UNNAMED_4_CAP_I1028_N2: length 1.7
  BOTTOM w0.203: C46.2 36.58,26.67 R43.1
UNNAMED_4_CAP_I1107_N2: length 1.4
  TOP w0.203: C18.2 R17.1
UNNAMED_4_DIOLED_I1138_N: length 2.3
  TOP w0.203: R417.2 53.34,2.5 DS2.C
UNNAMED_5_ADCLK914_I223_Q: length 4.3
  TOP w0.305: U16.12 13.98,20.01 arc(13.96,20.13) 13.89,20.24 13.14,20.98 R622.2
  TOP w0.33: R622.2 10.83,20.98 10.77,20.92 C4.1
UNNAMED_5_ADF4355_I299_CE: length 5.8
  TOP w0.203: U15.4 24.76,15.28 24.54,15.5 24.54,16.31 24.49,16.36 24.49,17.51 23.39,18.6 23.21,18.6 23.05,18.76 R611.1
UNNAMED_5_ADF4355_I299_CLK: length 1.9
  TOP w0.203: U15.1 26.26,14.98 R613.2
UNNAMED_5_ADF4355_I299_CREG2: length 2.3
  TOP w0.203: U15.32 v2(26.96,14.15)
  BOTTOM w0.203: v2(26.96,14.15) 26.96,13.77 26.81,13.61 26.81,13.5 C612.1 C617.1
UNNAMED_5_ADF4355_I299_DATA: length 1.5
  TOP w0.203: R614.2 25.76,15.62 U15.2
UNNAMED_5_ADF4355_I299_LE: length 1.5
  TOP w0.203: R615.2 25.26,15.53 U15.3
UNNAMED_5_ADF4355_I299_MUXOUT: length 2.2
  TOP w0.203: U15.30 27.42,12.65 27.69,12.91 27.69,13.42 27.94,13.68 28.38,13.68 R620.1
UNNAMED_5_ADF4355_I299_REFINA: length 4.2
  TOP w0.203: C611.2 R69.2 29.34,12.41 R612.1 28.32,12.15 U15.29
UNNAMED_5_ADF4355_I299_REFINB: length 3
  TOP w0.203: C610.2 R612.2 28.06,11.65 U15.28
UNNAMED_5_ADF4355_I299_RFOUTB: length 8.8
  TOP w0.305: U15.15 20.75,10.65 arc(20.49,10.6) 20.27,10.45 arc(20.12,10.23) 20.07,9.96 20.07,7.71 20.27,7.5 L64.1 20.27,6.3 20.05,6.08 20.05,5.6 20.37,5.28 R11.2 20.97,5.42 R13.1
UNNAMED_5_ADF4355_I299_RFOUTB_1: length 10.9
  TOP w0.305: U15.14 20.32,11.15 arc(19.98,11.08) 19.69,10.89 arc(19.5,10.6) 19.43,10.26 19.43,7.71 19.23,7.5 L63.2 19.23,6.3 19.44,6.08 19.44,5.28 20.08,4.65 R11.1 20.94,4.53 R12.1
UNNAMED_5_ADF4355_I299_RSET: length 1.6
  TOP w0.203: R618.1 25.23,8.3 25.23,8.96 25.26,9 U15.22
UNNAMED_5_ADF4355_I299_VBIAS: length 3.4
  TOP w0.203: U15.24 26.26,8.88 26.29,8.85 26.29,8.4 26.23,8.33 C637.1 v2(26.23,7.39)
  BOTTOM w0.203: C645.2 26.8,6.82 v2(26.23,7.39)
UNNAMED_5_ADF4355_I299_VREF: length 3.8
  TOP w0.203: U15.23 v2(25.76,8.62)
  BOTTOM w0.203: C648.1 25.21,8.72 25.66,8.72 v2(25.76,8.62) 25.78,8.6 25.78,7.7 25.69,7.61 25.69,7.33 C651.2
UNNAMED_5_ADM7150_I186_BYP: length 3.5
  TOP w0.203: U17.3 38.86,6.82 39.12,6.56 39.88,6.56 40.89,7.58 C659.2
UNNAMED_5_ADM7150_I186_REF: length 0.5
  TOP w0.203: 39.24,10.63 38.92,10.3 U17.6
UNNAMED_5_ADM7150_I186_VREG: length 3.5
  TOP w0.203: U17.1 37.86,6.83 37.34,6.31 36.32,6.31 36.07,6.06 C656.2
UNNAMED_5_ADM7154_I181_BYP: length 1.6
  BOTTOM w0.203: C661.2 2.67,9.11 U19.3
UNNAMED_5_ADM7154_I181_VIN: length 0.9
  BOTTOM w0.203: 3.56,13.17 3.48,13.09 U19.7 3.17,13.42 3.3,13.55
UNNAMED_5_ADM7154_I181_VOUT: length 1
  BOTTOM w0.305: 3.3,9.23 3.17,9.36 U19.2
UNNAMED_5_ADM7154_I181_VREG: length 2.2
  BOTTOM w0.203: C658.2 5.81,10.19 U19.1
UNNAMED_5_ADM7154_I297_BYP: length 3.3
  TOP w0.203: U18.3 12.32,11.19 12,11.51 10.28,11.51 C660.2
UNNAMED_5_ADM7154_I297_EN: length 0.9
  TOP w0.203: 13.08,7.07 12.82,7.33 U18.7
UNNAMED_5_ADM7154_I297_VREG: length 2.2
  TOP w0.203: v2(13.65,11.14) U18.1
  BOTTOM w0.203: C657.2 14.83,12.32 v2(13.65,11.14)
UNNAMED_5_CAP_I32_N2: length 2.3
  BOTTOM w0.203: R62.2 C66.2 R64.1
UNNAMED_5_CAP_I90_N1: length 10.4
  TOP w0.305: C633.1 13.72,14.59 arc(13.74,14.45) 13.82,14.33 13.9,14.26 arc(13.93,14.22) 13.95,14.18 13.97,14.13 13.97,13.44 arc(14.07,12.95) 14.34,12.54 14.36,12.52 arc(14.77,12.25) 15.26,12.15 16.55,12.15 arc(16.98,12.07) 17.35,11.82 L62.1 18.11,11.82 arc(18.32,11.86) 18.5,11.98 arc(18.68,12.11) 18.9,12.15 U15.12
UNNAMED_5_CAP_I203_N2: length 8
  TOP w0.203: C63.2 45.92,19.52 45.89,19.56 C65.2 43.95,19.56 Y61.6 41.53,17.14 JP1.1
UNNAMED_5_CAP_I269_N1: length 2.8
  TOP w0.203: U15.25 27.4,10.15 27.69,9.87 v2(27.69,9.23)
  BOTTOM w0.203: C620.1 C622.1 27.62,9.23 v2(27.69,9.23)
UNNAMED_5_CAP_I292_N1: length 1.7
  TOP w0.305: R12.2 23.13,4.53 R14.1 23.36,4.53 C638.1
UNNAMED_5_CAP_I293_N1: length 1.8
  TOP w0.305: C639.1 23.38,5.42 R14.2 23.1,5.42 R13.2
UNNAMED_5_CAP_I294_N1: length 9.6
  TOP w0.305: U15.11 18.5,12.65 arc(18.45,12.65) 18.4,12.67 18.39,12.67 arc(18.27,12.74) 18.17,12.82 18.07,12.91 arc(17.99,12.97) 17.89,12.99 L61.2 17.35,12.99 arc(16.98,12.75) 16.55,12.66 15.37,12.66 arc(14.74,12.92) 14.48,13.55 14.48,14.13 arc(14.51,14.3) 14.61,14.44 arc(14.7,14.58) 14.73,14.74 C632.1
UNNAMED_5_CAP_I329_N1: length 9.2
  TOP w0.203: L63.1 18.62,7.34 17.53,8.43 17.53,8.47 ; 18.41,4.79 18.29,4.91 v2(18.29,5.93)
  TOP w0.254: L64.2 21.13,7.07 v2(21.34,7.07) C628.1 ; L63.1 18.65,6.79 18.65,6.29 v2(18.29,5.93)
  L10_SIGNAL w0.203: v2(21.34,7.07) 20.5,6.23 19.08,6.23 18.77,5.93 v2(18.29,5.93)
UNNAMED_5_CAP_I349_N2: length 1.1
  BOTTOM w0.203: C62.2 R61.2
UNNAMED_5_CNBNC3P_I279_CNTR: length 11.6
  TOP w0.305: C4.2 9.27,20.92
  TOP w0.686: J62.1 4.95,13.61 arc(5.15,14.61) 5.72,15.45 arc(6.28,16.3) 6.48,17.29 6.48,17.85 arc(6.57,18.34) 6.85,18.75 8.84,20.74 arc(9.04,20.87) 9.27,20.92
UNNAMED_5_CNBNC3P_I308_CNTR: length 5.9
  TOP w0.203: R65.2 R629.1 J61.1
UNNAMED_5_DIOLED_I73_N: length 1.4
  TOP w0.203: DS61.C 24.85,20.32 R621.2
UNNAMED_5_DIOLED_I73_P: length 6
  TOP w0.203: v2(27.18,19.01) DS61.A ; R620.2 v2(28.45,15.33)
  BOTTOM w0.203: v2(27.18,19.01) 28.45,17.74 v2(28.45,15.33)
UNNAMED_5_FERRITE_I346_N1: length 1.8
  BOTTOM w0.203: E68.1 10.6,8.47
  BOTTOM w0.508: 10.6,8.47 R626.2
UNNAMED_5_FERRITE_I347_N1: length 1.8
  BOTTOM w0.203: E67.1 10.6,6.31
  BOTTOM w0.508: 10.6,6.31 R628.2
UNNAMED_5_FERRITE_I348_N1: length 1.8
  BOTTOM w0.203: E66.1 10.6,10.63
  BOTTOM w0.508: 10.6,10.63 R627.2
UNNAMED_5_RES_I49_N1: length 3.2
  TOP w0.203: 28.7,8.72 28.7,9.87 28.35,9.87 27.95,10.27 27.91,10.27 27.57,10.61 27.45,10.61 27.42,10.65 U15.26
UNNAMED_6_CAP_I116_N2: length 2.7
  TOP w0.203: U20.3 v2(52.21,64.59)
  BOTTOM w0.203: XC12.2 52.16,64.54 v2(52.21,64.59)
UNNAMED_6_CN6P_I38_N1: length 13.4
  TOP w0.203: U20.25 v2(56.52,60.29)
  BOTTOM w0.203: v2(56.52,60.29) 56.52,62.44 53.82,65.14 50.14,65.14 XP1.1
UNNAMED_6_CN6P_I38_N5: length 9.3
  TOP w0.203: XP1.5 59.05,62.06 XR2.2 57.93,60.94 U20.26
UNNAMED_6_DIOLED_I258_N: length 3.3
  TOP w0.203: U20.21 54.54,57.31 55.12,56.73 XCR1.C
UNNAMED_6_DIOLED_I258_P: length 5.9
  TOP w0.203: XR6.2 61.72,59.4 59.05,56.73 XCR1.A
UNNAMED_6_ICPIC18F2XJ50_I109_OS: length 1.8
  TOP w0.203: v2(49.02,63.36) 49.12,63.26 U20.7
  BOTTOM w0.203: R28.1 49.02,63.76 v2(49.02,63.36)
UNNAMED_6_ICPIC18F2XJ50_I109_RC: length 2.5
  TOP w0.203: U20.14 48.21,58.34 47.75,57.87 v2(47.75,57.49)
  BOTTOM w0.203: R10.1 47.62,56.6 47.62,57.36 v2(47.75,57.49)
UNNAMED_7_CAP_I162_N2: length 41.1
  TOP w0.203: v2(71.42,19.19) 71.01,18.78 59.92,18.78 44.55,34.15 44.55,34.75 41.32,37.98 41.32,38.06 40.68,38.7 C811.2
  BOTTOM w0.203: P1.B32 v2(71.42,19.19)
UNNAMED_7_CAP_I163_N2: length 41
  TOP w0.203: v2(71.42,17.92) 70.97,18.38 59.75,18.38 44.15,33.98 44.15,34.58 40.91,37.81 40.91,37.89 40.68,38.12 40.57,38.12 40.51,38.06 C812.2
  BOTTOM w0.254: P1.B33 v2(71.42,17.92)
UNNAMED_7_CAP_I164_N2: length 41
  TOP w0.203: v2(71.42,14.11) 71.01,13.71 70,13.71 69.79,13.5 58.8,13.5 42.93,29.37 42.93,30.76 41.52,32.17 40.27,32.17 C813.2
  BOTTOM w0.254: P1.B36 v2(71.42,14.11)
UNNAMED_7_CAP_I165_N2: length 41
  TOP w0.203: C814.2 40.27,31.71 41.33,31.71 42.47,30.57 42.47,29.18 58.61,13.04 69.98,13.04 70.19,13.25 71.01,13.25 v2(71.42,12.84)
  BOTTOM w0.254: P1.B37 v2(71.42,12.84)
UNNAMED_7_CAP_I166_N2: length 40.7
  TOP w0.203: C82.2 40.54,47.71 40.63,47.8 41.44,47.8 58.29,30.95 72.36,30.95 v2(72.69,30.62)
  BOTTOM w0.203: P1.A23 v2(72.69,30.62)
UNNAMED_7_CAP_I167_N2: length 40.7
  TOP w0.203: v2(72.69,31.89) 72.2,31.41 58.48,31.41 41.63,48.26 40.63,48.26 40.54,48.35 C81.2
  BOTTOM w0.203: P1.A22 v2(72.69,31.89)
UNNAMED_7_CAP_I168_N2: length 41.1
  TOP w0.203: C84.2 40.54,43.65 40.63,43.74 41.69,43.74 59.56,25.87 72.36,25.87 v2(72.69,25.54)
  BOTTOM w0.254: P1.A27 v2(72.69,25.54)
UNNAMED_7_CAP_I169_N2: length 41.2
  TOP w0.203: C83.2 40.54,44.28 40.63,44.19 41.88,44.19 59.75,26.33 72.2,26.33 v2(72.69,26.81)
  BOTTOM w0.254: P1.A26 v2(72.69,26.81)
UNNAMED_7_CAP_I170_N2: length 43.4
  TOP w0.203: C86.2 40.54,42 40.63,42.09 40.79,42.09 43.89,38.99 43.89,37.53 60.25,21.17 71.98,21.17 v2(72.69,20.46)
  BOTTOM w0.203: P1.A31 v2(72.69,20.46)
UNNAMED_7_CAP_I171_N2: length 43.1
  TOP w0.203: C85.2 40.54,42.63 40.63,42.54 40.98,42.54 44.35,39.18 44.35,37.72 60.44,21.63 71.98,21.63 72.09,21.73 v2(72.69,21.73)
  BOTTOM w0.203: P1.A30 v2(72.69,21.73)
UNNAMED_7_CAP_I172_N2: length 44.6
  TOP w0.203: C88.2 38.86,36.54 38.95,36.63 39.99,36.63 42.67,33.95 42.67,32.98 59.69,15.96 69.34,15.96 69.72,15.58 72.49,15.58 v2(72.69,15.38)
  BOTTOM w0.254: P1.A35 v2(72.69,15.38)
UNNAMED_7_CAP_I173_N2: length 44.8
  TOP w0.203: C87.2 38.86,37.17 38.95,37.08 40.18,37.08 43.13,34.13 43.13,33.17 59.88,16.42 69.53,16.42 69.91,16.04 72.07,16.04 v2(72.69,16.65)
  BOTTOM w0.254: P1.A34 v2(72.69,16.65)
UNNAMED_7_CAP_I174_N2: length 43.7
  TOP w0.203: v5(74.04,11.64) 73.66,12.03 72.39,12.03 71.88,11.52 58,11.52 41.1,28.42 41.1,29.85 41.04,29.91 40.75,29.91 40.65,29.81 C810.2
  BOTTOM w0.254: v5(74.04,11.64) 73.34,10.94 P1.A39
UNNAMED_7_CAP_I175_N2: length 43.7
  TOP w0.203: v5(74.04,12.91) 73.61,12.48 72.2,12.48 71.69,11.97 58.19,11.97 41.55,28.61 41.55,30.04 41.23,30.36 40.75,30.36 40.65,30.47 C89.2
  BOTTOM w0.254: P1.A38 73.34,12.21 v5(74.04,12.91)
UNNAMED_7_CAP_I176_N2: length 33.8
  TOP w0.203: C816.2 40.67,49.74 40.75,49.83 41.75,49.83 46.49,54.57 63.25,54.57 65.15,56.48 69.7,56.48 v2(70.15,56.02)
  BOTTOM w0.203: P1.C3 v2(70.15,56.02)
UNNAMED_7_CAP_I177_N2: length 33.8
  TOP w0.203: v2(70.15,57.29) 69.79,56.93 64.96,56.93 63.06,55.03 46.3,55.03 41.56,50.29 40.75,50.29 40.67,50.38 C815.2
  BOTTOM w0.203: P1.C2 v2(70.15,57.29)
UNNAMED_7_CN400PAKV2_I143_LA01N: length 16.4
  TOP w0.203: JP34.2 55.05,50.38 63.63,50.38 64.39,49.62 67.56,49.62 68.78,48.4 v2(68.88,48.4)
  BOTTOM w0.254: P1.D9 v2(68.88,48.4)
UNNAMED_7_CN400PAKV2_I143_LA01P: length 16.1
  TOP w0.203: JP33.2 55.05,50.76 64.01,50.76 64.77,50 68.55,50 v2(68.88,49.67)
  BOTTOM w0.254: P1.D8 v2(68.88,49.67)
UNNAMED_7_CN400PAKV2_I143_TDI: length 1.3
  BOTTOM w0.203: P1.D30 P1.D31
UNNAMED_7_CN400PAKV2_I147_LA02N: length 8.7
  TOP w0.203: v2(65.02,50.89) 64.39,51.52 JP32.2
  BOTTOM w0.203: v2(65.02,50.89) 64.45,50.31 P1.H8
UNNAMED_7_CN400PAKV2_I147_LA02P: length 8.8
  TOP w0.203: v2(65.02,52.16) 64.39,52.79 60.33,52.79 59.94,52.41 JP31.2
  BOTTOM w0.254: v2(65.02,52.16) 64.45,51.58 P1.H7
UNNAMED_7_ICM24CXX_I210_E2: length 2.3
  TOP w0.203: R88.2 71.81,62.96 U23.3
UNNAMED_9_ADM7154_I249_BYP: length 2.9
  BOTTOM w0.203: U14.3 37.22,60.37 37,60.16 36.54,60.16 35.48,59.1 C515.1
UNNAMED_9_ADM7154_I249_REF: length 2.9
  BOTTOM w0.203: C518.2 36.45,65.37 36.45,64.86 36.7,64.6 ; U14.6 37.22,64.35 36.96,64.6 36.7,64.6 ; U14.5 36.7,64.6
UNNAMED_9_ADM7154_I249_VREG: length 3.9
  BOTTOM w0.203: U14.1 38.22,60.37 39.74,58.85 C514.1
UNNAMED_9_ADM7154_I278_BYP: length 3.9
  TOP w0.203: C55.1 12.78,56.51 11.85,55.59 10.24,55.59 10.03,55.8 U13.3
UNNAMED_9_ADM7154_I278_REF: length 5.6
  TOP w0.203: C510.2 13.17,60.63 12.57,60.03 10.54,60.03 ; U13.6 10.03,59.77 10.29,60.03 10.54,60.03 ; 10.54,60.03 10.53,60.02 U13.5
UNNAMED_9_ADM7154_I278_VREG: length 3.4
  TOP w0.203: C51.1 7.75,54.52 9.03,55.8 U13.1
UNNAMED_9_ADP176X_I287_PG: length 1.7
  TOP w0.203: R24.2 24,57.62 23.62,57.23 U2.15
UNNAMED_9_ADP176X_I287_REFCAP: length 2.4
  TOP w0.203: C25.1 18.64,58.11 18.66,58.11 19.04,57.73 U2.5
UNNAMED_9_ADP176X_I287_SS: length 1.7
  TOP w0.203: C22.1 23.99,56.6 23.86,56.73 U2.14
UNNAMED_9_ADP176X_I287_VREG: length 2
  TOP w0.203: C30.1 18,57.23 U2.6
UNNAMED_9_ADP176X_I303_PG: length 1.7
  TOP w0.203: U3.15 34.16,57.23 R25.2
UNNAMED_9_ADP176X_I303_REFCAP: length 2.3
  TOP w0.203: C27.1 28.19,58.76 28.83,58.13 29.21,58.13 29.6,57.73 U3.5
UNNAMED_9_ADP176X_I303_SS: length 1.7
  TOP w0.203: C24.1 34.16,56.73 U3.14
UNNAMED_9_ADP176X_I303_VREG: length 1.9
  TOP w0.203: C40.1 28.16,57.23 U3.6
UNNAMED_9_CAPP_I31_N2: length 2
  TOP w0.203: C526.N R27.1
UNNAMED_10_CAP_I3_N1: length 2.1
  BOTTOM w0.203: U8.26 10.11,60.53 10.2,60.63 10.2,61.77 10.16,61.94 C64.1
UNNAMED_10_CAP_I4_N1: length 2.2
  BOTTOM w0.203: C60.1 11.3,61.8 10.92,61.42 10.92,60.98 10.61,60.66 U8.27
UNNAMED_10_CAP_I5_N1: length 2.4
  BOTTOM w0.203: C67.1 12.45,61.81 11.43,60.79 11.43,60.77 11.17,60.51 11.17,60.14 U8.28
UNNAMED_10_CAP_I7_N1: length 3.3
  BOTTOM w0.203: C57.1 7.87,61.94 R54.2 8.76,61.68 8.76,61.25 8.61,61.1 U8.23
UNNAMED_10_DIOLED_I29_P: length 1.5
  TOP w0.203: R327.2 DS1.A
UNNAMED_10_LINLTC2928_I1_DONEN: length 1.7
  BOTTOM w0.203: U8.18 4.72,58.62 R53.2
UNNAMED_10_LINLTC2928_I1_EN1: length 13.2
  TOP w0.203: Q2.2 v6(6.25,62.85)
  L2_GROUND w0.203: v6(6.25,62.85) 6.32,62.85 v3(6.73,62.44)
  L10_SIGNAL w0.203: v2(12.45,54.19) 12.45,56.22 8.13,60.54 8.13,61.81 7.49,62.44 v3(6.73,62.44)
  BOTTOM w0.203: U8.2 12.11,54.53 v2(12.45,54.19)
UNNAMED_10_LINLTC2928_I1_EN2: length 9
  TOP w0.203: Q3.2 v6(10.31,62.85)
  L2_GROUND w0.203: v6(10.31,62.85) 10.39,62.85 v3(10.79,62.44)
  L10_SIGNAL w0.203: v2(14.22,56.86) 14.22,57.75 10.79,61.17 v3(10.79,62.44)
  BOTTOM w0.203: v2(14.22,56.86) 13.99,56.62 U8.37
UNNAMED_10_LINLTC2928_I1_EN3: length 4.4
  TOP w0.203: v2(14.35,62.83) 14.38,62.85 Q4.2
  BOTTOM w0.203: v2(14.35,62.83) 14.1,62.57 14.1,60.92 13.72,60.54 12.83,60.54 12.61,60.32 U8.31
UNNAMED_10_LINLTC2928_I1_ON: length 4
  BOTTOM w0.203: R70.1 R71.1 R68.2 4.83,57.62 U8.16
UNNAMED_10_LINLTC2928_I1_OVA: length 4.1
  BOTTOM w0.203: U8.1 12.61,54.92 12.95,54.57 14.96,54.57 R76.1 R55.1
UNNAMED_10_LINLTC2928_I1_RT1: length 2
  BOTTOM w0.203: R56.1 9.91,53.95 10.11,54.15 U8.6
UNNAMED_10_LINLTC2928_I1_RT2: length 2.2
  BOTTOM w0.203: U8.7 9.61,54.65 8.76,53.81 R58.1
UNNAMED_10_LINLTC2928_I1_RT3: length 2.7
  BOTTOM w0.203: U8.8 9.11,54.79 8.5,54.19 8.12,54.19 7.62,53.69 R57.1
UNNAMED_10_LINLTC2928_I1_SQT1: length 4.2
  BOTTOM w0.203: U8.10 8.11,54.75 7.44,54.09 6.62,54.09 6.47,53.94 6.47,53.3 R78.1 R77.2
UNNAMED_10_LINLTC2928_I1_SQT2: length 5.6
  BOTTOM w0.203: R79.2 R80.1 4.19,53.4 5.26,54.47 7.28,54.47 7.61,54.79 U8.11
UNNAMED_10_LINLTC2928_I1_V1: length 4.1
  BOTTOM w0.203: U8.3 11.61,54.39 11.81,54.19 11.81,53.94 12.45,53.3 11.68,52.54 11.56,52.54 R75.1
UNNAMED_10_LINLTC2928_I1_V2: length 3
  BOTTOM w0.203: U8.38 15.09,56.12 R67.1 R66.2
UNNAMED_10_LINLTC2928_I1_V3: length 3
  BOTTOM w0.203: U8.32 15.09,59.12 R60.1 R59.2
UNNAMED_10_RES_I26_N1: length 45.2
  TOP w0.203: v2(7.4,64.35) 6.94,64.35 Q2.PAD2 6.9,63.94 Q2.3 6.9,62.15 R50.1
  L3_SIGNAL w0.203: v2(7.4,64.35) 8.29,63.46 10.54,63.46 11.81,64.73 15.62,64.73 16.89,63.46 v2(18.92,63.46) 19.43,63.97 20.57,63.97 21.08,63.46 27.81,63.46 v2(28.83,64.48) 31.88,67.52 v2(37.72,67.52)
  BOTTOM w0.203: R338.1 28.83,61.56 v2(28.83,64.48) ; R337.1 v2(18.92,63.46) ; R339.1 v2(37.72,67.52)
UNNAMED_10_TRANNMOSFET2PAD_I17_: length 3.1
  TOP w0.203: Q4.6 13.91,64.85 Q4.PAD1 ; Q4.6 Q4.5 ; Q4.6 12.62,65.03 R29.2
UNNAMED_10_TRANNMOSFET2PAD_I21_: length 3.1
  TOP w0.203: R40.2 8.56,65.03 Q3.6 ; Q3.PAD1 9.85,64.15 9.68,64.32 9.68,64.7 9.66,64.71 Q3.6 ; Q3.6 Q3.5
UNNAMED_10_TRANNMOSFET2PAD_I24_: length 3.1
  TOP w0.203: Q2.6 4.49,65.03 R30.2 ; Q2.6 Q2.5 ; Q2.6 5.6,64.31 Q2.PAD1
USB_D+: length 4
  TOP w0.254: U20.13 45.55,58.99 XP2.3
USB_D-: length 5.1
  TOP w0.203: 46.05,59.64 45.19,60.49 45.16,60.49 44.49,60.49 44.48,60.5 XP2.2
  TOP w0.254: 46.05,59.64 U20.12
USB_VCC: length 8.4
  BOTTOM w0.254: R9.1 46.99,55.84 46.99,56.22 47,56.22 47,58.76 44.83,60.92 XP2.1
  BOTTOM w0.508: R9.1 46.61,55.21 R10.2
VADJ: length 23.8
  TOP w0.254: v5(60.71,47.84) 60.48,47.61 U21.7 ; U22.2 67.84,39.99 67.56,39.71 v5(67.56,39.46) 66.8,40.22 U22.1 ; v5(65.02,44.54) 65.25,44.31 U22.10 63.77,43.5 R72.1 ; U21.2 60.48,44.43 60.31,44.27 U21.1 59.43,44.03 v5(59.82,43.65) ; U22.7 67.84,43.81 67.78,43.87 67.78,44.32 v5(67.56,44.54) ; U22.15 65.25,40.83 v5(65.15,40.73) ; v2(57.03,44.28) 57.56,44.81 U21.15
  TOP w0.508: C72.1 60.71,42.76 v5(59.82,43.65) ; v5(67.56,44.54) 67.56,45.3 67.06,45.81 C71.1 ; R73.1 v5(56.39,49.36)
  BOTTOM w0.254: P1.J39 v2(62.53,10.3) ; P1.E39 v2(67.61,10.3) ; P1.K40 v2(61.26,9.03) ; P1.G39 v2(65.07,10.3) ; P1.H40 v2(63.8,9.03)
  BOTTOM w0.508: v2(67.61,10.3) P1.F40 66.97,9.66 v2(66.29,8.98)
VNEG12: length 8.1
  TOP w0.508: R7.2 v5(20.32,44.41)
  L10_SIGNAL w0.635: 16.68,49.58 TP43.1 ; TP43.1 16.68,47.88 ; TP43.1 18.38,49.58
  BOTTOM w0.254: C537.2 26.23,38.44 v1(26.23,38.49) ; v1(27.03,40.09) 27.18,40.25 C533.2 ; C8.2 C534.2 25.31,41.81 v1(25.43,41.69) ; v1(25.43,37.69) 25.4,37.67 C531.2 ; v1(27.03,39.29) 27.21,39.11 C536.2 ; C543.2 26.19,40.89 v1(26.23,40.89)
  BOTTOM w0.508: v5(16.54,50.51) 16.32,50.72 C549.2
  vias: v1(25.43,36.09) v1(26.23,44.89) v5(15.95,52.18) v5(16.51,51.45)
VNEG12_EN: length 1.8
  BOTTOM w0.203: U12.5 19.44,60.65 R337.2
VOUT: length 11.9
  L6_POWER w0.203: v2(12.45,51.14) 14.48,51.14 14.99,51.65 14.99,52.54 15.37,52.92 v3(21.46,52.92)
  L11_GROUND w0.203: v4(21.46,53.68) v3(21.46,52.92)
  BOTTOM w0.203: R74.1 v2(12.45,51.14)
VREG: length 8.4
  L11_GROUND w0.203: v4(53.98,27.23) 53.98,27.49 54.13,27.65 v3(54.13,28.84) ; v4(50.65,28.43) 50.97,28.43 v3(51.26,28.71)
  BOTTOM w0.203: U10.45 v4(50.65,28.43) ; C410.2 54.36,27.01 54.14,27.23 v4(53.98,27.23) 53.98,27.77 52.96,28.79 R414.1
  BOTTOM w0.508: v2(38.67,28.97) 38.89,28.97 38.96,29.04 R416.2 R48.2 ; R49.2 v2(39.88,26.12)
VTUNE: length 9.1
  TOP w0.203: v2(24.06,7.52) 24.06,8.46 24.17,8.57 24.17,8.57 24.26,8.67 U15.20
  BOTTOM w0.203: v2(24.06,7.52) 21.64,7.52 21.16,8 19.13,8 18.58,7.45 C69.2 R64.2

## Copper pours and planes (outline as drawn)
GND on TOP: 27.56,68.41 75.95,68.41 75.95,0.47 22.86,0.47 22.86,3.14 11.94,3.14 11.94,5.29 0.51,5.29 0.51,65.49 27.43,65.49 27.56,65.62 ; 21 cut-outs
GND on BOTTOM: 27.56,68.41 75.95,68.41 75.95,0.47 22.86,0.47 22.86,3.14 11.94,3.14 11.94,5.29 0.51,5.29 0.51,65.49 27.43,65.49 27.56,65.62 ; 12 cut-outs
